# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_RSMRST#_R: length 2.8
  BOTTOM w0.102: U10.112 106.98,72.56 v2(107.11,72.43) 106.97,72.29 R177.1
PM_SYSRST#: length 189.2
  TOP w0.102: v1(117.17,23.59) v2(117.17,29.33) 117.17,31.46 116.44,32.2 116.44,33.99 v1(116.04,34.38) ; v1(86.9,16.14) 85.92,17.12 83.17,17.12 82.99,16.93 82.26,16.93 GR15.1
  IN1 w0.102: v1(116.04,34.38) 116.04,34.39 116.04,35.07 110.86,40.25 110.86,40.67 110.66,40.87 110.66,44.04 110.26,44.44 109.68,45.02 109.28,45.42 109.28,58.19 109.68,58.59 109.68,59.4 109.93,59.66 109.93,61 109.83,61.1 109.83,69.82 108.75,70.9 108.75,71.1 106.24,73.61 104.44,73.61 103.02,75.04 103.02,75.42 103.42,75.82 103.42,76.52 105.1,78.2 106.15,78.2 v1(106.35,77.99) ; v1(86.9,16.14) 86.9,16.29 89.96,19.35 95.02,19.35 97.12,17.25 98.84,17.25 101.43,19.84 101.81,19.84 105.56,23.59 v1(117.17,23.59)
  IN2 w0.102: v1(106.35,77.99) 105.68,78.66 99.42,78.66 97.94,77.18 97.21,77.18 96.05,78.34 92.15,78.34 91.41,79.07 89.16,79.07 88.91,78.83 88.91,77.91 88.13,77.13 75.03,77.13 74.13,78.03 69.01,78.03 68.11,77.13 64.29,77.13 64.03,76.88 58.82,76.88 58.02,77.68 50.59,77.68 49.55,78.71 45.75,78.71 45.51,78.95 43.97,78.95 42.45,77.43 40.51,77.43 39.17,78.77 38.22,78.77 37.82,78.38 37.82,77.79 37.49,77.46 33.8,77.46 v1(33.05,76.71)
  BOTTOM w0.102: v1(33.05,76.71) 33.38,76.37 PR7.2 33.76,75.72 33.76,76.55 33.91,76.7 PR216.1
PM_SYSRST#_R: length 15.5
  BOTTOM w0.089: U1.AC3 33.28,66.76 33.28,68.04 32.69,68.63 32.69,69.59
  BOTTOM w0.102: v2(34.8,79.35) 35.33,78.82 35.33,78.47 34.86,78 34.78,78 PR216.2 34.8,77.59 34.93,77.46 34.93,73.99 34.52,73.58 34.52,71.39 34.21,71.09 33.78,71.09 33.34,70.64 33.34,70.38 32.69,69.73 32.69,69.59
PM_THRMTRIP#: length 9.7
  TOP w0.089: 21.97,30.8 v1(22.76,30.8) ; 20.73,29.3 20.73,30.22 21.21,30.7
  TOP w0.102: 21.97,30.8 21.31,30.8 21.21,30.7 ; 20.73,29.3 v2(20.73,28.62) 19.89,28.62 19.61,28.34 19.61,27.93 20.65,26.89 20.65,25.56 SR15.1
  BOTTOM w0.089: U1.D60 22.43,31.13 v1(22.76,30.8)
POGO_ID_VOL_D: length 3.4
  BOTTOM w0.508: Q35.3 58.35,7.18 56.34,7.18 v2(55.73,6.57)
POGO_ID_VOL_G:
  vias: v2(60.89,4.61)
POGO_IN_OC#: length 62.2
  TOP w0.102: v1(127.97,67.23) 127.97,67.67 127.36,68.28 126.9,68.28 125.97,67.35 120.46,67.35 119.62,68.19 118.56,68.19 118.18,68.56 118.18,69.94 118.49,70.25 T59.1 118.49,71.09 116.89,72.69 v1(115.94,72.69) ; PQ9.3 137.48,38.17 138.44,39.12 138.44,41.85 139.04,42.45 140.16,42.45 v1(140.49,42.12)
  IN3 w0.102: v1(127.97,67.23) 128.4,67.23 128.58,67.05 128.58,64.95 128.16,64.53 128.16,60.89 128.82,60.23 128.82,59.54 130.48,57.88 133.68,57.88 135.59,55.97 136.38,55.97 137.68,54.67 137.68,54.13 137.17,53.62 137.17,52.57 138.2,51.54 138.2,48.46 139.88,46.78 141.15,46.78 141.89,46.04 141.89,44.82 140.49,43.43 v1(140.49,42.12)
  BOTTOM w0.102: R207.1 117.12,72.21 116.12,72.21 115.94,72.39 v1(115.94,72.69)
POGO_IN_OC#_EC1: length 7.1
  BOTTOM w0.102: U10.90 115.5,78.13 115.6,78.03 115.6,76.85 116.33,76.12 v2(116.33,75.96) 116.08,75.71 116.08,73.26 R207.2
PQ24A_G: length 13.2
  TOP w0.102: PQ10.3 141.33,37.45 v2(141.72,37.07) 141.72,36.07 140.29,34.64 139.06,34.64 138.17,33.75 136.3,33.75 136.04,34 136.04,35.73 PR68.2 136.52,36.59 136.83,36.9 PQ9.2
PRESSURE_INT1: length 22.7
  TOP w0.102: U19.9 158.57,54.54 159.07,55.04 159.07,58.53 159.97,59.43 v2(159.97,60.57) 159.51,61.03 159.51,65.5 160.58,66.57 160.58,69.23 160.89,69.54 160.89,71.26 160.61,71.54 160.07,71.54 v1(159.64,71.98)
  BOTTOM w0.102: v1(159.64,71.98) 160.17,72.51 160.66,72.51 160.86,72.31 U20.31
PROC_OPI_COMP: length 11.7
  BOTTOM w0.089: 47.75,58.87 47.52,59.1 46.36,59.1 45.68,59.78 43.93,59.78 43.33,59.18 U1.AY15
  BOTTOM w0.102: 47.75,58.87 47.86,58.77 47.86,56.43 48.94,55.35 HR43.1 50.55,54.8 v2(50.55,54.17)
PWM_LED_A: length 101.5
  TOP w0.102: v2(179.91,75.28) 180.32,75.68 v1(180.32,76.7) 180.32,78.08 C178.1
  IN1 w0.102: v1(180.32,76.7) 180.54,76.93 180.54,84.35 180.16,84.73 180.16,85.98 v1(179.66,86.48) 179.38,86.76 177.78,86.76 177.47,87.06 168.84,87.06 167.48,88.42 152.17,88.42 150.24,86.49 133.78,86.49 132.24,84.95 127.68,84.95 126.33,83.61 114.95,83.61 114.12,84.44 111.72,84.44 111.19,83.91 102.28,83.91 v1(101.59,84.6)
  BOTTOM w0.102: CON11.11 181.75,85.58 181,86.33 179.81,86.33 v1(179.66,86.48) ; U10.25 100.86,85.33 v1(101.59,84.6)
PWM_LED_W: length 98.9
  IN1 w0.102: v1(179.6,76.67) 180.33,77.4 180.33,84.03 179.27,85.08 179.27,86.1 v1(179.05,86.33) 177.24,86.33 176.81,86.76 168.85,86.76 167.39,88.22 152.26,88.22 150.33,86.29 133.86,86.29 132.33,84.75 127.76,84.75 126.42,83.41 114.87,83.41 114.03,84.24 111.8,84.24 110.68,83.12 107.55,83.12 106.98,83.68 101.78,83.68 v1(100.86,84.6)
  BOTTOM w0.102: C179.1 179.86,76.42 v1(179.6,76.67) ; v1(179.05,86.33) 179.33,86.05 180.65,86.05 181.25,85.44 CON11.10 ; U10.24 100.53,84.93 v1(100.86,84.6)
PWR_DEBUG: length 60.7
  TOP w0.102: GR13.2 56.61,7.15 56.48,7.03 v1(56.48,6.44)
  IN1 w0.102: v1(93.04,7.84) 91.16,7.84 89.9,6.58 87.23,6.58 84.35,3.71 65.45,3.71 64.05,5.11 60.31,5.11 58.95,3.75 56.03,3.75 55.03,4.75 55.03,5.09 56.38,6.44 v1(56.48,6.44)
  BOTTOM w0.102: GR24.2 101.16,8.13 v2(101.32,8.29) GR27.2 100.71,10.1 100.71,10.71 99.84,11.59 98.63,11.59 97.68,10.63 97.06,10.63 96.96,10.53 96.96,10.13 96.47,9.64 GU2.2 93.99,9.64 GR26.1 93.69,8.49 v1(93.04,7.84)
PWR_DEBUG_R: length 28.4
  TOP w0.102: XDP1.45 78.28,5.08 v1(78.18,5.17) ; v2(55.4,6.57) 55.96,6.01 56.69,6.01 v1(57.12,6.44) 57.27,6.6 58.41,6.6 GR13.1
  IN1 w0.102: v1(78.18,5.17) 76.38,5.17 75.57,4.36 65.37,4.36 64.22,5.52 58.04,5.52 v1(57.12,6.44)
PWR_SW: length 50.2
  IN2 w0.102: v1(92.02,75.05) 92.02,74.9 93.81,73.12 98.59,73.12 99.36,73.89 108.14,73.89 109.09,72.94 v1(109.35,72.94)
  BOTTOM w0.102: U10.106 109.38,73.28 109.35,73.25 v1(109.35,72.94) ; v1(92.02,75.05) 91.81,75.26 91.81,77.22 v2(91.16,77.87) 91.16,79.66 90.22,80.6 90.22,83.85 89.46,84.62 89.46,87.77 87.09,90.14 81.61,90.14 81.05,89.58 79.76,89.58 79.35,89.17 79.35,88.93 78.49,88.06 78.1,88.06 R435.2 76.66,87.17 76.32,87.5 HQ3.1
PWR_SW#: length 127.4
  TOP w0.102: v1(93.85,42.56) 93.85,41.27 v2(96.09,39.03) 99.16,35.96 v1(99.87,35.96) ; v1(94.34,66.51) 96.5,68.67 98.17,68.67 98.93,69.44 100.79,69.44 101.3,69.94 101.3,71.77 100.81,72.25 100.81,72.46 101.19,72.83 v1(101.83,72.83) 102.33,72.83 102.68,73.18 R208.2 ; GR12.2 62.02,6.44 60.55,6.44 59.2,7.79 58.02,7.79 57.89,7.92 57.89,8.72 58.28,9.11 59.4,9.11 59.79,9.5 59.79,10.41 60.42,11.03 61.33,11.03 v1(61.52,11.22)
  BOTTOM w0.102: v1(101.83,72.83) 101.78,72.89 U10.125 ; v1(94.34,66.51) 93.3,66.51 93.24,66.46 93.24,43.17 v1(93.85,42.56) ; v1(99.87,35.96) 99.87,34.76 99.42,34.31 99.42,31.93 100.98,30.37 100.98,20.91 99.9,19.83 99.9,12.49 99.2,11.79 98.43,11.79 98.26,11.63 89.9,11.63 88.66,12.87 87.25,12.87 86.49,12.11 75.11,12.11 73.94,13.28 72.26,13.28 71.56,13.97 67.16,13.97 65.2,12.02 62.32,12.02 v1(61.52,11.22)
PWR_SW#_R: length 41.9
  TOP w0.102: v2(100.33,73.5) 100.56,73.27 101.95,73.27 102.11,73.43 102.11,73.94 R208.1 R206.2 101.64,74.93 v1(101.92,75.21)
  IN2 w0.102: v1(101.92,75.21) 101.36,75.21 100.81,75.76 96.24,75.76 95.28,76.73 92.57,76.73 91.93,76.09 91.01,76.09 v1(90.63,76.47)
  BOTTOM w0.102: D9201.1 80.19,88.16 R434.2 80.33,87.46 81.04,87.46 81.6,88.02 82.79,88.02 82.93,88.15 82.93,88.97 83.4,89.45 87.21,89.45 89.05,87.61 89.05,84.46 89.26,84.24 89.26,83.29 89.08,83.11 89.08,81.17 90.46,79.79 90.46,76.92 90.63,76.75 v1(90.63,76.47)
PWRBTN#: length 168.9
  TOP w0.102: v1(174.65,84.9) 174.65,86.22 174.35,86.53 169.29,86.53 167.45,88.37 157.31,88.37 156.36,87.43 156.36,86.15 155.96,85.75 SW1.3 155.09,84.71 153.82,85.97 151.79,85.97 v2(151.31,86.45) 150.82,86.45 149.07,84.71 SW1.1
  IN1 w0.102: v1(143.73,85.44) 144.38,86.09 150.51,86.09 152.44,88.02 167.31,88.02 168.77,86.56 173.8,86.56 174.6,85.75 174.6,84.95 v1(174.65,84.9)
  IN2 w0.102: v1(140.26,75.23) 140.26,75.2 139.71,74.66 122.12,74.66 121.13,73.66 114.53,73.66 113.41,74.79 113.41,75.63 112.81,76.23 109.01,76.23 108.57,75.8 101.42,75.8 101.26,75.96 96.33,75.96 95.36,76.93 92.48,76.93 92.06,76.51 v1(91.26,76.51)
  BOTTOM w0.102: CON11.9 180.75,85.27 180.18,85.84 178.8,85.84 177.78,86.86 175.85,86.86 174.6,85.61 174.6,85.44 174.42,85.26 174.18,85.26 C180.1 174.13,84.9 v1(174.65,84.9) ; v1(91.26,76.51) 91.26,76.74 90.67,77.33 90.67,79.87 89.28,81.26 89.28,83.02 89.46,83.21 89.46,84.32 89.26,84.53 89.26,87.69 87.07,89.88 83.55,89.88 82.72,89.06 82.72,88.33 82.61,88.22 81.4,88.22 81.05,87.88 R434.1 80.74,88.37 80.96,88.59 82.07,88.59 82.13,88.65 D9201.3 ; v1(143.73,85.44) 143.73,83.51 144.65,82.59 144.65,76.45 143.94,75.73 140.77,75.73 v1(140.26,75.23)
PWRSW_SHM: length 115.2
  TOP w0.102: PR226.2 164.82,68.27 164.82,69.56 165.53,70.27 v2(165.53,70.93) 165.53,71.45 v1(165.84,71.76)
  IN1 w0.102: v1(142.34,73.96) 142.75,73.55 144.66,73.55 147.68,70.53 147.68,67.65 148.6,66.73 153,66.73 154.86,68.59 161.35,68.59 163.4,70.64 164.72,70.64 v1(165.84,71.76)
  IN2 w0.102: v1(142.34,73.96) 142.06,73.68 122.61,73.68 121.65,72.72 117.86,72.72 117.05,71.92 110.38,71.92 109.78,72.51 109.78,73.37 109.06,74.1 99.28,74.1 98.5,73.32 94.2,73.32 v1(92.64,74.88)
  BOTTOM w0.102: HQ3.3 78.4,89.7 78.92,90.22 D9201.2 80.62,90.64 86.88,90.64 89.66,87.86 89.66,84.7 90.43,83.94 90.43,80.69 91.48,79.63 91.48,78.52 92.12,77.88 92.12,75.69 92.64,75.17 v1(92.64,74.88)
PWRSW_SHM_R: length 5.1
  TOP w0.102: v2(165.33,69.05) 166.13,68.26 PR226.1 166.13,67.35 166.13,67.35 R436.2 166.13,66.26 166.1,66.23 C400.2 166.5,65.43 PQ34.1
R_BIAS: length 6.9
  TOP w0.178: U6.64 166.14,26.2 166.65,26.71 167.29,26.71 167.35,26.77 C67.1 ; C67.1 168.33,27.11 168.33,27.22 v2(168.99,27.88) ; C67.1 167.99,26.34 168.2,26.13 169.42,26.13 R132.2
RCIN#: length 99.7
  TOP w0.089: v1(31.1,66.16) 30.68,66.58 30.68,68.93
  TOP w0.102: v1(31.68,76.48) 31.91,76.25 32.05,76.25 32.64,75.66 32.64,74.83 SR13.2 32.11,74.3 32.11,71.98 31.78,71.65 31.55,71.65 30.68,70.78 30.68,68.93 ; v1(97.11,74.52) 97.11,74.46 97.16,74.41 v2(97.16,73.5)
  IN3 w0.102: v1(92.18,72.64) 92.6,73.05 94.19,73.05 96.07,74.93 96.69,74.93 v1(97.11,74.52) ; v1(91.52,82.69) 90.77,81.94 86.29,81.94 86.03,82.2 83.12,82.2 82.61,81.69 74.65,81.69 74.32,82.02 65.39,82.02 64.21,83.2 63.04,83.2 62,82.16 60.21,82.16 58.99,80.94 57.74,80.94 56.84,80.04 56,80.04 55.2,79.24 54.41,79.24 53.97,78.8 51.57,78.8 50.88,78.1 48.05,78.1 46.47,76.52 45.29,76.52 44.63,77.18 39.9,77.18 39.19,76.47 38.05,76.47 37.89,76.64 37.17,76.64 36.73,76.19 35.4,76.19 34.56,75.35 33.03,75.35 32.09,76.29 31.87,76.29 v1(31.68,76.48)
  BOTTOM w0.089: v1(31.1,66.16) 30.8,65.85 U1.V4
  BOTTOM w0.102: v1(97.11,74.52) 97.6,75.01 97.6,75.55 97.77,75.72 97.77,76.47 98.23,76.93 U10.4 ; v1(91.52,82.69) 91.7,82.52 91.7,78.6 93.06,77.24 93.06,74.53 92.18,73.65 v1(92.18,72.64)
RSVD31: length 7.1
  TOP w0.089: HT57.1 41.12,67.17 41.78,67.83 41.78,68.88 v1(41.34,69.32)
  BOTTOM w0.089: 40.06,68.93 40.06,68.36 40.19,68.24 40.19,67.6 40.47,67.32 U1.AT2
  BOTTOM w0.102: 40.06,68.93 40.06,69.32 40.31,69.57 41.1,69.57 v1(41.34,69.32)
RSVD33: length 3.9
  BOTTOM w0.089: U1.AV44 42.13,40.37 43.8,40.37 44,40.57 44.98,40.57 HT61.1
RSVD34: length 2.3
  TOP w0.089: v1(22.7,59.87) 22.7,59.75 HT62.1
  BOTTOM w0.089: v1(22.7,59.87) 22.7,59.78 U1.D15
RSVD35: length 4
  TOP w0.089: v1(23.73,55.62) 23.32,55.2 23.32,54.83 23.12,54.63 23.12,54.3 23.52,53.89 HT65.1
  BOTTOM w0.089: 23.57,55.46 v1(23.73,55.62)
  BOTTOM w0.102: U1.F22 23.57,55.46
RSVD36: length 2.2
  TOP w0.089: HT67.1 25.3,54.17 v1(25.09,54.17)
  BOTTOM w0.089: v1(25.09,54.17) U1.H22
RSVD38: length 2.5
  TOP w0.089: v1(27.94,54.12) 27.43,53.62 HT55.1
  BOTTOM w0.089: v1(27.94,54.12) U1.N23
RSVD39: length 4.5
  TOP w0.089: HT56.1 27.94,50.79 v1(27.94,53.46)
  BOTTOM w0.089: v1(27.94,53.46) 28.37,53.89 28.37,54.31 U1.R23
RSVD40: length 2.4
  TOP w0.089: HT58.1 29.24,53.41 v1(29.16,53.48)
  BOTTOM w0.089: U1.T23 29.56,53.9 29.57,53.9 29.57,53.88 29.17,53.48 v1(29.16,53.48)
RSVD41: length 1.8
  TOP w0.089: v1(30.18,61.95) 30.66,62.44 HT60.1
  BOTTOM w0.089: U1.U10 30.08,61.95 v1(30.18,61.95)
RSVD42: length 5.6
  BOTTOM w0.089: 38.74,70.3 39.35,70.3 39.7,70.65 ; 37.7,68.93 37.7,68.03 U1.AL1
  BOTTOM w0.102: 37.7,68.93 37.7,69.26 38.74,70.3 ; 39.7,70.65 39.79,70.74 40.29,70.74 40.54,71 HT63.1
RSVD44: length 4.4
  TOP w0.089: v1(41.36,65.35) 41.36,65.61 HT66.1
  BOTTOM w0.089: U1.AP7 39.49,63.81 39.51,63.8 39.69,63.8 39.72,63.77 40.06,63.77 40.09,63.8 40.34,63.8 40.37,63.77 40.66,63.77 40.89,64 40.89,64.88 v1(41.36,65.35)
RSVD45: length 11.5
  BOTTOM w0.089: U1.AU10 41.23,62.1 41.35,61.99 41.53,61.8 42.03,61.8 42.12,61.72 43.55,61.72 43.82,61.99 44.63,61.99 44.68,61.94 47.75,61.94
  BOTTOM w0.102: HT68.1 51.61,61.94 47.75,61.94
RSVD46: length 1.5
  TOP w0.089: HT70.1 41.23,59.26 v1(41.52,59.55)
  BOTTOM w0.089: v1(41.52,59.55) 41.52,59.53 41.19,59.2 U1.AU15
RSVD47: length 4.5
  BOTTOM w0.089: U1.AW14 42.78,60.22 43.45,60.22 43.64,60.4 46.65,60.4 HT71.1
RSVD48: length 5.8
  BOTTOM w0.089: 47.75,60.19 47.41,60.19 47.02,59.8 46.45,59.8 46.03,60.23 43.71,60.23 43.42,59.93 U1.AY14
  BOTTOM w0.102: 47.75,60.19 HT72.1
RSVD49: length 4
  TOP w0.089: v1(18.95,66.21) 20.78,66.21 HT40.1
  BOTTOM w0.089: U1.A5 20.22,65.55 19.61,65.55 v1(18.95,66.21)
RSVD50: length 3.6
  TOP w0.089: HT42.1 20.73,68.44 20.73,68.62 v1(21.13,69.03)
  BOTTOM w0.089: v1(21.13,69.03) 21.41,69.03 22.18,68.27 22.74,68.27 23.04,67.97 U1.E1
RSVD51: length 2.9
  TOP w0.089: HT44.1 22.12,67.4 v1(21.13,68.39)
  BOTTOM w0.089: U1.D1 21.79,68.39 v1(21.13,68.39)
RSVD52: length 3.4
  TOP w0.089: HT45.1 24.26,54.98 24.26,55.73 v1(24.76,56.24)
  BOTTOM w0.102: U1.J20 25.58,56.63 25.18,56.24 v1(24.76,56.24)
RSVD53: length 2.5
  TOP w0.089: HT46.1 24.21,57.57 24.95,57.57 v1(25.4,58.02)
  BOTTOM w0.089: U1.H18 25.4,57.9 v1(25.4,58.02)
RSVD54: length 3.6
  BOTTOM w0.089: 20.04,41.47 20.19,41.62 20.85,41.62 U1.B43
  BOTTOM w0.102: 20.04,41.47 HT21.1
RSVD55: length 9.1
  TOP w0.089: v1(28.63,25.85) 28.63,24.86 28.65,24.83 HT29.1
  BOTTOM w0.089: v1(28.63,25.85) 28.36,26.12 27.66,26.12 27.01,26.77 27.01,27.7 27.41,28.1 27.41,29.63 27.36,29.68 27.36,30.83 U1.N60
RSVD56: length 2.1
  TOP w0.089: v1(31.37,54.16) 32.11,53.42 HT32.1
  BOTTOM w0.089: v1(31.37,54.16) 31.19,54.33 U1.W23
RSVD57: length 4.2
  TOP w0.089: v1(31.42,53.5) 31.12,53.19 HT33.1
  BOTTOM w0.089: v1(31.42,53.5) 31.78,53.85 31.78,54.38 31.6,54.56 U1.Y22
RSVD58: length 2.4
  TOP w0.089: v1(42.59,28.54) 42.12,29 HT37.1
  BOTTOM w0.089: v1(42.59,28.54) 42.59,28.58 42.17,28.99 42.17,29.49 U1.AV62
RSVD59: length 6
  BOTTOM w0.089: HT39.1 17.63,31.26 18.85,31.26 19.83,32.24 21.28,32.24 21.35,32.17 21.63,32.17 21.66,32.2 21.98,32.2 22.01,32.17 22.31,32.17 22.61,32.47 U1.D58
RSVD60: length 5.4
  TOP w0.089: v1(29.87,57.75) 29.57,57.45 29.57,55.49 29.34,55.26 29.08,55.26 HT41.1
  BOTTOM w0.089: v1(29.87,57.75) 29.24,57.12 28.84,57.12 U1.P20
RSVD61: length 9.4
  TOP w0.089: HT43.1 29.57,52.06 29.74,52.24 29.74,55.36 29.82,55.44 29.82,57.07 v1(30.48,57.73)
  BOTTOM w0.089: v1(30.48,57.73) 29.38,56.63 U1.R20
RSVD_6: length 2.5
  TOP w0.089: v1(24.71,55.61) 24.93,55.61 T4.1
  BOTTOM w0.102: v1(24.71,55.61) 24.81,55.61 25.22,56.02 25.39,56.02 25.52,56.15 U1.K21
RSVD_7: length 3.9
  TOP w0.089: v1(27.68,57.23) 27.43,56.99 27.43,56.3 27.03,55.9 T5.1
  BOTTOM w0.089: v1(27.68,57.23) 27.65,57.23 27.13,56.7 U1.M21
RSVD_69: length 6.9
  TOP w0.089: v1(28.47,27.95) 28.47,27.92 27.94,27.39 27.94,25.8 27.89,25.75 HT9.1
  BOTTOM w0.089: U1.P60 28.85,30.75 28.85,28.98 29.03,28.8 29.03,28.4 28.58,27.95 v1(28.47,27.95)
RSVD_70: length 2.6
  TOP w0.089: v1(28.07,30.18) 27.71,29.82 HT10.1
  BOTTOM w0.089: v1(28.07,30.18) 28.37,30.48 U1.P61
RSVD_71: length 1.3
  TOP w0.089: v1(28.07,31.45) 28.47,31.84 HT11.1
  BOTTOM w0.089: v1(28.07,31.45) 27.74,31.78 U1.N59
RSVD_72: length 2
  TOP w0.089: v1(28.06,30.81) 28.78,30.1 HT12.1
  BOTTOM w0.089: U1.N61 27.81,30.63 27.89,30.63 v1(28.06,30.81)
RSVD_TP5: length 13
  BOTTOM w0.089: 42.96,25.37 42.96,26.44 43.6,27.08 43.6,27.41 43.37,27.65 42.91,27.65 42.19,28.37 42.19,28.64 41.99,28.84 41.99,29.03 U1.AV63
  BOTTOM w0.102: HT13.1 47.83,23.41 44.86,23.41 42.96,25.31 42.96,25.37
RSVD_TP8: length 17.7
  TOP w0.089: v1(27.33,32.17) 27.49,32.33 28.86,32.33 29.17,32.02 29.17,30.01 29.57,29.61 29.57,25.24 30.18,24.63 30.18,23.08
  TOP w0.102: HT26.1 29.8,19.14 30.18,19.52 30.18,23.08
  BOTTOM w0.089: U1.L60 27.33,31.48 v1(27.33,32.17)
RSVD_TP9: length 14.1
  BOTTOM w0.089: U1.C62 21.49,29.42 21.49,26.53 22.66,25.37
  BOTTOM w0.102: 22.66,25.37 22.66,25.32 24.5,23.48 24.5,19.69 HT19.1
RSVD_TP10: length 3.9
  BOTTOM w0.089: U1.C63 21.83,28.75 21.71,28.63
  BOTTOM w0.102: HT18.1 22.8,26.24 22.32,26.24 21.87,26.7 21.87,27 21.71,27.17 21.71,28.63
RSVD_TP11: length 10.9
  BOTTOM w0.089: U1.AU63 41.19,29.03 41.83,28.39 41.83,28.22 42.75,27.3 42.75,25.37
  BOTTOM w0.102: HT17.1 47.14,22.13 46.45,22.82 45.16,22.82 42.75,25.22 42.75,25.37
RSVD_TP55: length 3.2
  BOTTOM w0.089: 19,36.67 20.26,36.67 U1.A51
  BOTTOM w0.102: 19,36.67 18.03,36.67 HT23.1
RSVD_TP66: length 4.1
  TOP w0.102: v1(18.37,37.3) 17.93,36.87 HT24.1
  BOTTOM w0.089: U1.B51 20.88,37.21 20.28,37.21 19.97,36.9 18.77,36.9 v1(18.37,37.3)
RSVL: length 12
  TOP w0.102: v2(157.66,34.28) 158.09,34.71 160.22,34.71 160.54,34.4 160.54,33.27 160.22,32.95 160.22,32.26 R131.2 160.07,31.04 160.07,28.87 160.5,28.44 160.5,27.98 161.29,27.2 U6.11
RTC_RST#: length 14.8
  TOP w0.102: v1(42.14,62.56) 42.6,62.56 47.04,67 48.87,67 49.21,67.34 R77.2 50.56,67.85 T1.1 50.9,67.5 C52.1 51.74,68.34 R76.1
  BOTTOM w0.089: U1.AU7 41.3,63.54 41.57,63.27 41.97,63.27 42.14,63.09 v1(42.14,62.56)
RTC_RST#_R: length 53.7
  TOP w0.102: v1(88.7,83.3) 89.59,84.19 91.85,84.19 92.15,84.5 E2.10 ; R76.2 52.56,68.36 52.56,70.9 53.71,72.05 53.71,74.02 54.32,74.63 54.32,75.65 54.95,76.29 54.95,79.35 56.03,80.43 v2(56.57,80.43) 57.03,80.43 59.58,82.99 60.43,82.99 60.7,83.25 61.72,83.25 62.18,82.8 63.94,82.8 64.1,82.64 68.18,82.64 v1(68.94,83.41)
  IN1 w0.127: v1(80.14,83.8) 80.82,83.8 81.82,82.8 85.5,82.8 86.01,83.3 v1(88.7,83.3)
  IN3 w0.102: v1(80.14,83.8) 69.33,83.8 v1(68.94,83.41)
RTC_X1: length 11
  BOTTOM w0.089: 45.91,70.65 45.91,70.38 45.99,70.31 46.18,70.12 v2(46.18,68.62) 46.18,68.22 43.5,65.54 42.86,65.54 U1.AW5
  BOTTOM w0.102: 45.91,70.65 45.91,70.85 46.09,71.02 R70.1 46.09,71.81 C49.1 46.64,72.86 46.49,73.01 X1.1
RTC_X2: length 11.4
  BOTTOM w0.089: U1.AY5 43.46,65.22 43.75,65.5 43.89,65.5 44.23,65.84 45.25,65.84 v2(46.28,66.87) 46.28,67.89 46.69,68.29 46.69,70.07 46.93,70.31 46.93,70.65
  BOTTOM w0.102: X1.4 47.39,72.98 47.64,72.74 C50.1 47.64,72.31 46.93,71.59 R70.2 46.93,70.65
SATA2GP: length 26.3
  IN2 w0.089: v1(30.16,64.12) 29.72,64.56 29.72,65.47 29.08,66.11 29.08,66.95 27.44,68.59 27.44,70.52 27.86,70.93
  IN2 w0.102: v1(37.03,78.5) 36.76,78.22 36.76,78 36.43,77.67 33.3,77.67 32.39,76.75 32.39,75.71 32.08,75.4 31.52,75.4 31.43,75.49 30.56,75.49 30.35,75.29 30.35,73.43 27.86,70.93
  BOTTOM w0.089: U1.V6 30.56,64.52 v1(30.16,64.12)
  BOTTOM w0.102: SR51.2 35.93,77.2 35.94,77.19 SR59.1 36.73,77.46 36.73,78.2 v1(37.03,78.5) 36.94,78.6 v2(36.94,79.23)
SATA3GP: length 8.4
  BOTTOM w0.089: U1.AC1 32.87,67.91 32.87,68.2 32.51,68.56 32.51,69.66 32.23,69.94 v2(32.23,70.2) 32.21,70.22 32.21,70.26
  BOTTOM w0.102: SR60.1 34.44,73.87 34.32,73.75 34.32,72.27 SR52.2 33.39,71.34 32.42,71.34 32.21,71.13 32.21,70.26
SATA_COMP: length 23.3
  TOP w0.102: v1(11.85,72.39) 11.74,72.39 11.44,72.1 SR7.1 ; v2(16.61,59.25) 17.68,59.25 18.42,59.99 v1(18.42,60.19)
  IN1 w0.127: v1(11.85,72.39) 12.14,72.1 14.68,72.1 16.28,70.5 16.28,64.13 16.87,63.54 16.87,61.43 17.2,61.1 17.5,61.1 v1(18.42,60.19)
  BOTTOM w0.089: U1.C12 21.06,60.69 20.7,60.34 18.56,60.34 v1(18.42,60.19)
SATA_RXN0: length 232.9
  TOP w0.102: CX3.1 v1(177.01,46.22)
  IN3 w0.089: 17.81,43.7 17.82,43.71 18.73,43.71 18.95,43.93 19.79,43.93 20.91,45.05 20.91,46.96 21.36,47.42 21.36,48.73 22.66,50.03 22.66,54.22 22.23,54.65 22.23,57.97 23.13,58.87 23.6,58.87 24.21,59.48 24.21,60.01 24.64,60.44 24.64,62.09 24.21,62.53 24.21,63.01 24.97,63.77 24.97,64.23 25.05,64.31 25.3,64.31 25.39,64.4 v1(25.39,64.74)
  IN3 w0.114: v1(177.01,46.22) 177.45,45.79 177.45,45.33 175.29,43.17 173.05,43.17 169.47,39.59 169.47,38.87 168.07,37.48 168.07,32.34 165.82,30.09 158.97,30.09 158.72,30.34 154.72,30.34 153.81,29.43 142.02,29.43 138.36,25.77 105.61,25.77 100.61,20.77 97.75,20.77 96.02,19.04 90.96,19.04 88.19,16.27 87.94,16.27 85.45,13.78 78.32,13.78 75.29,10.76 60.43,10.76 60,11.19 53.01,11.19 51.51,12.69 45.95,12.69 42.14,16.5 30.87,16.5 28.17,19.21 27.34,19.21 26.87,19.67 26.87,20.69 22.84,24.73 21.92,24.73 20.83,25.82 20.83,26.94 16.56,31.21 16.56,32.48 14.47,34.57 14.47,41.25 16.91,43.7 17.81,43.7
  BOTTOM w0.089: U1.J5 25.56,65.35 25.47,65.35 25.39,65.27 v1(25.39,64.74)
SATA_RXN0_C: length 3.8
  TOP w0.102: CON3.S5 186.37,46.22 183.98,46.22 C9218.2
SATA_RXN0_C_DR: length 2.1
  TOP w0.102: CX3.2 177.43,48.23 177.43,48.91 177.23,49.11 U21.4
SATA_RXN0_DR: length 13.3
  TOP w0.102: C9218.1 182.14,46.17 181.99,46.17 v1(181.87,46.04) ; U21.12 177.23,53.63 177.53,53.92 177.53,54.31 v4(177.2,54.63)
  IN1 w0.127: v1(181.87,46.04) 181.59,46.32 181.34,46.32 179.48,48.18 179.48,48.61 177.98,50.11 177.98,53.54 177.52,54 177.52,54.31 v4(177.2,54.63)
SATA_RXN1: length 134.2
  TOP w0.102: v1(93.55,20.57) 93.35,20.36 93.2,20.36 93.08,20.49 93.08,21.3 ; 93.08,21.3 v2(93.37,21.3) ; 93.08,21.3 93.08,22.1 93.22,22.24 93.95,22.24 94.21,21.98 95.22,21.98 95.35,21.86 95.35,21.4 95.48,21.27 C122.2
  IN3 w0.089: v1(25.34,62.84) 25.34,62.56 25.4,62.5 25.66,62.5 26.14,62.03 26.14,56.18 23.73,53.77 23.73,50.03 22.61,48.91 22.61,47.97 21.57,46.93 21.57,44.83 21.03,44.29 21.03,43.48 20.32,42.77 18.85,42.77 18.74,42.88 18,42.88 17.99,42.87 17.96,42.87 17.92,42.83 17.91,42.83
  IN3 w0.114: 17.91,42.83 17.26,42.83 15.32,40.89 15.32,34.97 17.43,32.86 17.43,31.69 18.26,30.85 18.64,30.85 21.46,28.03 21.46,27.57 27.76,21.28 29.16,21.28 31.85,18.58 33.33,18.58 34.49,17.42 42.49,17.42 46.35,13.56 56.14,13.56 56.72,12.97 61.29,12.97 62.05,12.21 65.56,12.21 66.32,12.97 76.29,12.97 78.32,15 84.69,15 89.82,20.13 92.99,20.13 93.07,20.21 93.07,20.69 93.22,20.85 93.45,20.85 93.55,20.74 v1(93.55,20.57)
  BOTTOM w0.102: U1.J8 25.51,63.3 25.34,63.12 v1(25.34,62.84)
SATA_RXN1_C: length 6.7
  TOP w0.102: v1(98.6,21.43) 98.95,21.77 98.95,21.87 98.83,21.98 97.35,21.98 97.21,21.84 97.21,21.63 97.28,21.56 97.28,21.43 97.13,21.27 C122.1
  BOTTOM w0.102: CONSATA.43 97.02,21.83 97.16,21.98 97.16,22.03 97.26,22.13 98.25,22.13 98.6,21.78 v1(98.6,21.43)
SATA_RXP0: length 233
  TOP w0.102: v1(178,46.22) 178.11,46.32 CX4.1
  IN3 w0.089: 17.81,43.9 17.82,43.9 17.83,43.89 18.65,43.89 18.87,44.11 19.71,44.11 20.73,45.13 20.73,47.03 21.19,47.49 21.19,48.81 22.48,50.1 22.48,54.15 22.05,54.58 22.05,58.04 23.05,59.05 23.52,59.05 24.03,59.55 24.03,60.09 24.46,60.52 24.46,62.02 24.03,62.45 24.03,63.08 24.77,63.82 v1(24.77,64.76)
  IN3 w0.114: v1(178,46.22) 177.67,45.89 177.67,45.24 175.38,42.94 173.15,42.94 169.7,39.5 169.7,38.78 168.3,37.38 168.3,32.25 165.91,29.86 158.88,29.86 158.62,30.12 154.81,30.12 153.9,29.2 142.11,29.2 138.46,25.54 105.71,25.54 100.71,20.54 97.84,20.54 96.12,18.81 91.05,18.81 88.29,16.04 88.03,16.04 85.54,13.56 78.41,13.56 75.39,10.53 60.33,10.53 59.9,10.96 52.92,10.96 51.42,12.46 45.86,12.46 42.05,16.27 30.78,16.27 28.07,18.98 27.24,18.98 26.65,19.58 26.65,20.6 22.74,24.5 21.83,24.5 20.6,25.73 20.6,26.85 16.33,31.11 16.33,32.38 14.24,34.48 14.24,41.35 16.79,43.9 17.81,43.9
  BOTTOM w0.089: 25.08,65.07 v1(24.77,64.76)
  BOTTOM w0.102: U1.H5 25.08,65.07
SATA_RXP0_C: length 3.8
  TOP w0.102: C9219.2 183.86,46.42 186.28,46.42 CON3.S6
SATA_RXP0_C_DR: length 2
  TOP w0.102: U21.5 177.73,49.11 177.63,49.02 177.63,48.29 CX4.2
SATA_RXP0_DR: length 13.4
  TOP w0.102: v1(177.97,54.96) 177.97,54.67 177.73,54.43 U21.11 ; C9219.1 182.23,46.45 182.12,46.45 v1(181.89,46.68)
  IN1 w0.127: v1(177.97,54.96) 177.75,54.74 177.75,54.09 178.21,53.64 178.21,50.21 179.71,48.71 179.71,48.28 181.43,46.55 181.76,46.55 v1(181.89,46.68)
SATA_RXP1: length 134.1
  TOP w0.102: 94.71,22.19 94.3,22.19 94.04,22.45 93.14,22.45 92.88,22.19 92.88,20.4 93.12,20.16 93.3,20.16 v1(93.55,19.91) ; 94.71,22.19 v2(94.71,22.48) ; 94.71,22.19 C121.2
  IN3 w0.089: 17.91,43.06 18.81,43.06 18.92,42.94 20.25,42.94 20.85,43.55 20.85,44.37 21.39,44.9 21.39,47 22.43,48.05 22.43,48.99 23.55,50.1 23.55,53.84 25.96,56.25 25.96,61.95 25.59,62.32 25.17,62.32 v1(24.66,62.84)
  IN3 w0.114: 17.91,43.06 17.17,43.06 15.09,40.98 15.09,34.87 17.2,32.76 17.2,31.6 18.17,30.62 18.54,30.62 21.24,27.93 21.24,27.47 27.66,21.05 29.07,21.05 31.76,18.36 33.23,18.36 34.4,17.19 42.39,17.19 46.25,13.33 56.04,13.33 56.62,12.74 61.2,12.74 61.96,11.98 65.65,11.98 66.42,12.74 76.39,12.74 78.42,14.77 84.78,14.77 89.91,19.91 v1(93.55,19.91)
  BOTTOM w0.102: v1(24.66,62.84) 25.08,63.26 U1.H8
SATA_RXP1_C: length 7
  TOP w0.102: 98.86,22.19 98.92,22.19 99.15,21.95 99.15,21.52 v1(99.24,21.43) ; 98.86,22.19 C121.1 ; 98.86,22.19 v2(98.86,22.48)
  BOTTOM w0.102: CONSATA.41 98.34,22.33 v1(99.24,21.43)
SATA_STRAP: length 140
  TOP w0.102: v2(93.78,78.3) 92.71,79.37 v1(92.36,79.37)
  IN2 w0.102: v1(92.36,79.37) 92.01,79.71 88.93,79.71 88.62,79.4 87.61,79.4 85.96,77.74 75.28,77.74 74.35,78.67 68.79,78.67 67.86,77.74 63.9,77.74 63.65,77.49 59.08,77.49 58.23,78.34 55.21,78.34 53.41,80.14 50.22,80.14 49.2,79.12 45.92,79.12 45.68,79.35 43.6,79.35 43.21,79.74 41.17,79.74 40.6,79.18 38.24,79.18 37.83,79.59 37.46,79.59 37.24,79.37 33.96,79.37 32.27,77.68 31.34,77.68 31,77.34 v1(31,75.91)
  BOTTOM w0.089: U1.U1 29.98,68.06 29.9,68.14 29.9,68.87 29.88,68.88 ; 30.48,68.93 30.48,68.4 30.73,68.15 U1.V1
  BOTTOM w0.102: SR62.2 31.46,78.12 SR63.1 30.43,78.12 SR61.1 30.42,76.49 v1(31,75.91) ; v1(31,75.91) 31.75,75.16 31.75,73.23 32.06,72.92 32.06,71.93 31.62,71.49 31.19,71.49 30.48,70.78 30.48,68.93 ; v1(31,75.91) 30.55,75.46 30.55,73.71 30.22,73.38 30.22,72.23 SR3.2 29.73,70.76 29.88,70.61 29.88,68.88 ; v1(92.36,79.37) 92.36,78.22 93.26,77.32 93.26,74.4 92.6,73.74 92.6,71.95 92.97,71.58 92.97,70.68 93.21,70.45 93.21,66.87 93.04,66.71 93.04,42.74 96.12,39.67 PQ8.3 97.72,36.85 97.77,36.9 PQ7.3
SATA_TXN0: length 238.6
  TOP w0.102: v1(174.12,40.89) 173.66,41.34 173.66,41.47 173.48,41.65 172.98,41.65 171.48,43.15 171.48,47.61 171.75,47.88 172.6,47.88 C196.1
  IN3 w0.114: v1(174.12,40.89) 173.94,40.71 173.94,40.18 173.58,39.82 171.58,39.82 170.71,38.96 170.71,37.9 169.17,36.35 169.17,31.88 166.21,28.92 157.58,28.92 156.84,28.19 142.5,28.19 138.48,24.17 105.72,24.17 98.38,16.84 97.58,16.84 94.07,13.33 92,13.33 89.28,10.61 82.09,10.61 78.81,7.33 77.59,7.33 76.84,6.58 60.35,6.58 59.88,7.05 53.65,7.05 52.81,7.89 50.7,7.89 50.54,8.04 50.53,8.04 48.73,9.85 44.71,9.85 40.95,13.61 28.99,13.61 26.25,16.35 23.25,16.35 16.13,23.47 16.13,24.99 14.78,26.33 14.78,26.89 12.68,29 12.68,31.38 10.72,33.34 10.72,38.73 10.44,39.01 10.44,43.57 11.95,45.08 11.95,45.57 13.57,47.19 13.57,55.87 16.92,59.22 18.1,59.22 18.41,59.53 19.46,59.53 19.94,59.05 19.94,58.86 20.01,58.79 v1(20.01,58.45)
  BOTTOM w0.089: U1.B15 20.4,58.53 20.31,58.45 v1(20.01,58.45)
SATA_TXN0_C: length 3.8
  TOP w0.102: CON3.S3 186.38,42.71 186.38,42.71 186.33,42.66 183.96,42.66 C9217.2
SATA_TXN0_C_DR: length 4.5
  TOP w0.102: 175.06,47.82 174.27,47.82 C196.2 ; 175.06,47.82 v2(175.06,47.53) ; 175.06,47.82 175.97,47.82 176.31,48.16 176.31,48.86 176.23,48.94 U21.2
SATA_TXN0_DR: length 20.9
  TOP w0.102: v4(178.45,42.84) 178.65,42.64 182.08,42.64 C9217.1 ; v1(176.26,54.65) 175.94,54.33 175.94,53.95 176.02,53.87 176.15,53.87 176.23,53.78 U21.14
  IN1 w0.127: v1(176.26,54.65) 175.69,54.08 175.69,53.81 175.39,53.52 175.39,47.05 176.72,45.71 176.72,42.9 177.09,42.54 178.14,42.54 v4(178.45,42.84)
SATA_TXN1: length 135.2
  TOP w0.102: C123.2 95.42,19.88 95.22,19.88 94.95,19.61 94.95,18.99 ; v1(94.03,17.24) 94.18,17.39 94.34,17.39 94.46,17.26 94.46,17.04 94.34,16.91 94.34,16.83 94.44,16.73 94.63,16.73 94.95,17.05 94.95,18.99 ; 94.95,18.99 v2(94.65,18.99)
  IN3 w0.114: v1(18.66,58.44) 18.66,58.25 18.46,58.05 18.04,58.05 17.96,57.97 17.96,57.6 15.19,54.83 15.19,47.24 13.03,45.08 13.03,44.44 11.69,43.1 11.69,39.36 11.81,39.23 11.81,33.77 13.79,31.79 13.79,29.65 19.74,23.71 19.74,23.08 22.4,20.41 23.55,20.41 26.52,17.44 26.87,17.44 29.54,14.77 41.35,14.77 45.16,10.96 49.15,10.96 51.03,9.09 53.28,9.09 54.2,8.17 60.35,8.17 60.85,7.66 65.99,7.66 66.7,8.37 71.93,8.37 72.57,9.01 76.25,9.01 78.94,11.7 88.7,11.7 89.97,12.97 89.97,13.99 92.56,16.58 93.44,16.58 93.78,16.92 93.78,16.98 v1(94.03,17.24)
  BOTTOM w0.089: 19.31,57.95 19.32,57.94 20.34,57.94 U1.A17
  BOTTOM w0.102: 19.31,57.95 18.77,57.95 18.66,58.06 v1(18.66,58.44)
SATA_TXN1_C: length 7.7
  TOP w0.102: 98.1,19.85 97.72,20.24 C123.1 ; 98.1,19.85 98.5,19.45 98.5,18.94 v1(98.73,18.71) ; 98.1,19.85 v2(98.32,20.08)
  BOTTOM w0.102: CONSATA.47 97.98,20.83 98.73,20.08 v1(98.73,18.71)
SATA_TXP0: length 238.6
  TOP w0.102: v1(173.46,40.89) 173.46,41.39 173.4,41.44 172.9,41.44 171.27,43.07 171.27,47.69 171.67,48.09 172.6,48.09 C197.1
  IN3 w0.114: v1(19.4,58.43) 19.71,58.75 19.71,58.95 19.36,59.3 18.5,59.3 18.2,59 17.01,59 13.79,55.78 13.79,47.09 12.17,45.47 12.17,44.98 10.67,43.48 10.67,39.11 10.95,38.83 10.95,33.43 12.9,31.48 12.9,29.09 15.01,26.99 15.01,26.43 16.36,25.08 16.36,23.56 23.34,16.58 26.34,16.58 29.08,13.83 41.05,13.83 44.81,10.08 48.82,10.08 50.62,8.27 50.64,8.27 50.79,8.12 52.91,8.12 53.75,7.28 59.97,7.28 60.44,6.81 76.75,6.81 77.5,7.56 78.72,7.56 81.99,10.84 89.19,10.84 91.91,13.56 93.98,13.56 97.49,17.07 98.29,17.07 105.62,24.4 138.39,24.4 142.4,28.41 156.74,28.41 157.48,29.15 166.12,29.15 168.94,31.97 168.94,36.44 170.49,37.99 170.49,39.05 171.48,40.05 173.48,40.05 173.71,40.28 173.71,40.63 v1(173.46,40.89)
  BOTTOM w0.089: 20.02,59.05 20.21,58.86 U1.A15
  BOTTOM w0.102: v1(19.4,58.43) 19.05,58.78 19.05,58.95 19.15,59.05 19.31,59.05 19.51,58.84 19.64,58.84 19.84,59.05 20.02,59.05
SATA_TXP0_C: length 3.8
  TOP w0.102: C420.2 183.85,42.46 186.32,42.46 CON3.S2
SATA_TXP0_C_DR: length 4.1
  TOP w0.102: U21.1 175.73,49.03 175.85,48.91 175.97,48.91 176.1,48.78 176.1,48.24 175.89,48.02 174.39,48.02 C197.2
SATA_TXP0_DR: length 20.9
  TOP w0.102: v1(178.43,41.96) 178.9,42.44 182.19,42.44 C420.1 ; v4(175.46,54.66) 175.73,54.39 U21.15
  IN1 w0.127: v4(175.46,54.66) 175.46,53.91 175.16,53.61 175.16,46.95 176.49,45.62 176.49,42.81 177,42.31 178.08,42.31 v1(178.43,41.96)
SATA_TXP1: length 135.3
  TOP w0.102: v1(94.03,16.53) 94.71,16.53 95.15,16.97 95.15,17.44 ; 95.15,17.44 v2(95.44,17.44) ; 95.15,17.44 95.15,19.52 95.3,19.68 95.44,19.68 C124.2
  IN3 w0.114: v1(94.03,16.53) 93.71,16.53 93.53,16.35 92.65,16.35 90.2,13.89 90.2,12.88 88.79,11.47 79.04,11.47 76.35,8.78 72.66,8.78 72.03,8.15 66.8,8.15 66.09,7.43 60.76,7.43 60.25,7.94 54.1,7.94 53.19,8.86 50.94,8.86 49.06,10.74 45.07,10.74 41.26,14.55 29.45,14.55 26.78,17.21 26.42,17.21 23.45,20.18 22.31,20.18 19.51,22.99 19.51,23.61 13.57,29.56 13.57,31.7 11.58,33.68 11.58,39.14 11.46,39.27 11.46,43.19 12.8,44.53 12.8,45.17 14.96,47.34 14.96,54.93 17.73,57.69 17.73,58.21 v1(17.98,58.46)
  BOTTOM w0.089: U1.B17 19.2,57.76
  BOTTOM w0.102: v1(17.98,58.46) 18.68,57.76 19.2,57.76
SATA_TXP1_C: length 7.4
  TOP w0.102: C124.1 97.3,20.03 97.63,20.03 98.3,19.36 98.3,18.94 v1(98.07,18.71)
  BOTTOM w0.102: CONSATA.49 97.16,20.33 97.21,20.38 97.21,20.57 97.27,20.63 97.9,20.63 98.53,20 98.53,19.17 v1(98.07,18.71)
SATALED#: length 9.4
  BOTTOM w0.089: 28.85,70.65 28.85,68.97 28.66,68.78 28.66,68.44 28.95,68.16 28.95,67.67 29.16,67.46 29.35,67.46 29.59,67.22 29.59,66.93 U1.U3
  BOTTOM w0.102: SR8.1 29.19,74.46 29.29,74.36 29.29,73.36 28.85,72.92 28.85,70.65
SCE#: length 15.8
  BOTTOM w0.102: R213.1 112.42,70.17 112.49,70.17 113.82,68.85 113.82,67.19 113.45,66.82 111.5,66.82 108.14,63.47 v2(107.47,63.47) 106.76,64.18 U11.1 106.03,65.06 105.63,65.46 R219.2
SCE#_EC: length 2.9
  BOTTOM w0.102: U10.101 111.38,72.58 v2(111.56,72.41) 111.99,71.97 R213.2
SCK: length 4.7
  BOTTOM w0.102: R214.1 110.28,68.38 111.06,67.6 U11.6
SCK_EC: length 2.9
  BOTTOM w0.102: R214.2 110.28,71.89 109.78,72.38 ; 109.78,72.38 109.78,72.39 U10.105 ; 109.78,72.38 v2(109.78,72.37)
SCL_3A: length 49
  TOP w0.102: v1(61.02,85.77) 60.57,85.31 59.84,85.31 59.58,85.04 58.73,85.04 56.17,82.49 54.15,82.49 v2(52.48,80.81) 52,80.33 52,78.86 52.17,78.68 52.17,78.16 51.11,77.09 51.11,76.2 48.95,74.04 48.95,72.53 48.72,72.31 RN1.2 48.36,71.69 48.03,71.37 48.03,71.16 v1(47.85,70.97)
  IN1 w0.127: v1(67.82,85.41) 67.47,85.77 61.02,85.77 61.02,85.77 v1(61.02,85.77)
  IN3 w0.089: 47.86,70.96 48.08,70.74 48.08,70.45 47.46,69.82 46.87,69.82 44.58,67.52 42.51,67.52 42.02,68.01 42.02,69.63 41.75,69.9 39.75,69.9 v1(39.18,69.33)
  IN3 w0.102: v1(47.85,70.97) 47.86,70.96
  BOTTOM w0.089: U1.AP2 39.39,67.49 39.39,68.93
  BOTTOM w0.102: 39.39,68.93 39.39,69.11 v1(39.18,69.33) ; SQ1.6 70.73,87.09 SR73.2 69.53,85.89 68.31,85.89 v1(67.82,85.41)
SDA_3A: length 49.9
  TOP w0.089: 47.28,70.68 v1(47.51,70.45)
  TOP w0.102: 47.28,70.68 47.21,70.76 47.21,72.16 47.35,72.31 RN1.4 47.71,72.79 47.78,72.86 48.46,72.86 48.69,73.1 48.69,74.15 50.85,76.31 50.85,78.08 51.74,78.97 51.74,81.43 v2(53,82.68) 53.18,82.86 56,82.86 58.44,85.3 59.47,85.3 59.92,85.74 v1(60.39,85.74)
  IN1 w0.127: v1(60.39,85.74) 60.87,86.22 63.37,86.22 64.48,87.33 v1(65.14,87.33)
  IN3 w0.089: v1(47.51,70.45) 46.97,70.45 46.52,70.01 44.44,70.01 44.1,69.66 42.95,69.66 42.53,70.08 39.36,70.08 38.43,69.16 37.85,69.16 37.5,68.8 v1(36.23,68.8)
  BOTTOM w0.089: U1.AH1 35.98,68.11 36.08,68.22 36.08,68.67 36.22,68.8 v1(36.23,68.8)
  BOTTOM w0.102: SQ1.3 68.21,88.86 67.98,89.08 SR74.2 67.85,90.11 67.49,89.75 67.49,88.46 67.18,88.16 65.36,88.16 65.14,87.94 v1(65.14,87.33)
SENSOR1: length 117.9
  TOP w0.102: v1(112.78,86.64) 112.47,86.95 v2(112.47,87.29)
  IN2 w0.102: v1(112.78,86.64) 112.26,86.12 99.08,86.12 97.87,87.33 94.63,87.33 93.77,88.19 75.03,88.19 73.59,86.76 67.02,86.76 66.21,85.95 65.23,85.95 64.74,85.45 61.3,85.45 61,85.15 56.29,85.15 56.05,85.39 52.27,85.39 51.75,85.91 38.56,85.91 38.03,86.44 37.37,86.44 35.76,84.83 31.2,84.83 31.05,84.68 25.27,84.68 22.92,82.34 21.8,82.34 18.93,79.47 17.87,79.47 14.45,76.05 14.45,74.08 15.03,73.51 v1(15.03,71.12)
  BOTTOM w0.102: v1(112.78,86.64) 113.06,86.92 113.06,87.61 113.31,87.86 113.82,87.86 113.95,87.73 U10.66 ; v1(15.03,71.12) 15.03,71.08 15.51,70.6 PRT3.1 15.03,70.59 14.63,70.19 14.63,69.82 PR57.1 C87.1
SENSOR2: length 149.9
  TOP w0.102: PRT1.1 115.53,17.94 116.1,18.51 120.4,18.51 122.27,20.38 128.42,20.38 135.23,27.18 v1(135.23,29.51)
  IN1 w0.102: v1(157.58,41.96) 157.14,41.52 154.87,41.52 151.55,38.21 144.9,38.21 136.2,29.51 v1(135.23,29.51) ; v1(144.1,72.41) 144.51,72.41 146.74,70.18 146.74,66.78 147.7,65.82 155.17,65.82 155.67,66.31 156.24,66.31 v1(156.82,65.73)
  IN2 w0.102: v1(157.58,41.96) 157.12,41.5 156.63,41.5 153.8,44.32 153.8,62.7 v1(156.82,65.73)
  BOTTOM w0.102: U10.71 115.58,85.73 116.4,86.56 116.41,86.56 116.49,86.63 116.49,87.58 C83.1 116.88,87.98 PR55.1 117.33,90.1 127.27,90.1 128.74,88.63 128.74,83.09 130.17,81.67 136.92,81.67 137.4,81.19 137.4,78.06 138.33,77.13 138.33,76.12 138.91,75.53 139.27,75.53 v2(139.4,75.4) 140.01,74.79 141.23,74.79 141.71,75.28 143.21,75.28 144.1,74.39 v1(144.1,72.41)
SENSOR3: length 56.6
  TOP w0.102: v2(81.88,85.97) 81.88,85.27 v1(82.07,85.08)
  IN3 w0.102: v1(110.21,84.38) 109.77,83.94 100.2,83.94 99.72,83.46 98.58,83.46 97.92,82.8 93.63,82.8 92.54,83.89 90.22,83.89 90.02,84.09 85.09,84.09 83.63,85.55 82.54,85.55 v1(82.07,85.08)
  BOTTOM w0.102: U10.73 110.76,84.93 v1(110.21,84.38) ; v1(82.07,85.08) 81.05,86.1 77.8,86.1 75.78,84.07 72.98,84.07 71.88,82.97 68.43,82.97 66.8,84.6 66.8,85.44 PR56.1 PRT2.1 C84.1
SERIRQ: length 165.8
  TOP w0.102: R110.2 27.13,72.56 27.15,72.59 SR14.2 26.72,73.41 26.72,74.2 26.54,74.39 26.54,75.63 v1(26.82,75.9) ; v1(96.47,74.51) 96.59,74.4 v1(96.59,70.22) ; v2(131.75,29.68) v1(131.75,30.45) R165.2
  IN1 w0.127: v1(131.75,30.45) 129.17,33.02 109.62,33.02 101.6,41.04 101.6,47.15 96.35,52.39 96.35,61.78 98.2,63.62 98.2,68.61 v1(96.59,70.22)
  IN3 w0.102: v1(96.47,74.51) 96.1,74.51 94.39,72.8 93.02,72.8 92.18,71.96 90.63,71.96 90.08,72.52 88.07,72.52 86.53,74.06 84.2,74.06 v1(83.45,74.81) ; v1(79.88,85.07) 79.4,85.55 78.03,85.55 77.46,84.98 68.41,84.98 68.26,84.83 62.37,84.83 62.15,84.61 61.64,84.61 60.81,83.79 59.51,83.79 58.29,82.57 57.07,82.57 56.17,81.67 55.32,81.67 54.64,80.98 50.3,80.98 49.04,79.73 47.12,79.73 46.61,79.21 43.8,79.21 42.54,80.48 41.09,80.48 40.21,79.6 38.3,79.6 38.05,79.85 37.38,79.85 37.19,79.66 36.48,79.66 35.89,79.06 33.68,79.06 33.01,78.4 28.6,78.4 27.15,76.95 27.15,76.24 v1(26.82,75.9)
  BOTTOM w0.102: v1(96.47,74.51) 96.47,75.63 96.68,75.84 R188.1 ; v1(83.45,74.81) 81.04,77.23 81.04,84.23 80.2,85.07 v1(79.88,85.07)
SERIRQ_EC: length 4.5
  BOTTOM w0.102: U10.5 96.97,77.33 R188.2 97.26,76.46 97.26,75.51 v2(96.98,75.23)
SERIRQ_PCH: length 8.2
  TOP w0.089: v1(29.23,65.35) 29.03,65.55 29.03,66.39 29.47,66.83 29.47,68.88 28.05,70.3 v2(27.2,70.3) 27.2,70.68
  TOP w0.102: R110.1 27.13,70.91 27.2,70.83 27.2,70.68
  BOTTOM w0.089: v1(29.23,65.35) 29.19,65.39 U1.T4
SERIRQ_TPM: length 8.5
  TOP w0.102: v2(132.01,27.93) 131.13,28.81 131.13,29.93 131.27,30.07 131.27,32.53 131.43,32.69 R165.1 131.75,33.39 131.52,33.62 131.52,35.58
SH_RST#_EC: length 56.9
  IN3 w0.102: v1(156.69,78.45) 154.09,75.85 141.19,75.85 140.11,76.93 135.23,76.93 134.8,76.5 112.09,76.5 111.49,77.1 107.86,77.1 v1(107.41,76.65)
  BOTTOM w0.102: R60369.1 155.77,79.38 v1(156.69,78.45) 157.02,78.78 v2(157.02,79.19) ; U10.109 108.18,75.71 107.41,76.48 v1(107.41,76.65)
SH_RST#_IO: length 155.7
  TOP w0.089: 40.2,70 39.77,69.57
  TOP w0.102: v1(155.98,78.46) 155.82,78.3 v2(154.92,78.3) ; 40.2,70 40.45,70.25 40.45,73.84 41.1,74.49 41.3,74.49 41.76,74.95 41.76,75.47 SR36.2 42.64,76.34 42.64,76.94 43.26,77.56 43.47,77.56 SR70.2 44.52,77.93 44.68,78.1 45.59,78.1 45.87,78.38 45.87,79.67 46.19,79.99 46.19,81.68 47.25,82.75 48.31,82.75 50.03,84.46 55.4,84.46 58.4,87.46 63.5,87.46 63.92,87.88 70.2,87.88 70.64,88.32 82.93,88.32 83.94,87.31 83.94,84.07 83.1,83.23 v1(82.59,83.23) ; 39.77,69.57 39.77,68.83 v1(37.12,66.18)
  IN3 w0.102: v1(155.98,78.46) 153.78,76.26 144.31,76.26 143.89,76.69 140.63,76.69 140.19,77.13 135.13,77.13 134.7,76.7 115.58,76.7 113.92,78.36 109.54,78.36 108.75,77.57 106.12,77.57 105.5,78.2 102.67,78.2 102.29,77.82 99.85,77.82 98,75.96 96.23,75.96 93.94,73.66 89.78,73.66 89.33,73.22 88,73.22 86.9,74.32 85.31,74.32 v1(84.81,74.81)
  BOTTOM w0.089: v1(37.12,66.18) 37.01,66.18 U1.AK4
  BOTTOM w0.102: R60368.1 v1(155.98,78.46) ; v1(84.81,74.81) 84.36,74.81 81.54,77.63 81.54,81.92 82.59,82.97 v1(82.59,83.23)
SH_WAKE_IO: length 157.8
  TOP w0.089: v1(32.09,64.73) 31.67,65.14 31.67,66.89 31.05,67.52 31.05,68.93
  TOP w0.102: 31.05,68.93 31.05,70.76 31.66,71.37 SR35.2 32.32,71.86 32.32,73.79 32.84,74.31 32.84,75.75 32.15,76.44 32.15,76.6 31.85,76.9 31.6,76.9 v1(31.42,77.08)
  IN1 w0.102: v1(149.68,67.91) 149.68,68.62 151.08,70.02 151.08,73.96 150.03,75.01 146.81,75.01 146.18,75.65 131.43,75.65 129.95,77.13 129.95,80.23 128.8,81.37 108.37,81.37 107.59,82.16 107.59,82.46 106.82,83.22 99.97,83.22 99.07,82.33 92.51,82.33 91.68,81.5 87.76,81.5 87.63,81.37 80.93,81.37 v1(80.16,82.14)
  IN3 w0.102: v1(80.16,82.14) 79.85,82.14 79.61,81.89 74.73,81.89 74.4,82.22 65.48,82.22 64.3,83.41 62.96,83.41 61.92,82.36 60.13,82.36 58.91,81.14 57.66,81.14 56.76,80.24 55.91,80.24 55.11,79.44 54.11,79.44 53.67,79 51.49,79 50.8,78.31 47.97,78.31 46.41,76.75 45.37,76.75 44.73,77.39 39.82,77.39 39.11,76.67 38.18,76.67 38.01,76.84 37.09,76.84 36.64,76.39 34.16,76.39 33.6,75.84 33.05,75.84 32.39,76.5 32.26,76.5 31.85,76.9 31.6,76.9 v1(31.42,77.08)
  BOTTOM w0.089: U1.AB6 32.31,64.52 32.1,64.73 v1(32.09,64.73)
  BOTTOM w0.102: v1(149.68,67.91) 149.68,68.85 v2(149.53,69) 149.53,69.69 149.79,69.94 149.79,70.8 R429.2
SH_WAKE_IO_R: length 2.8
  BOTTOM w0.102: R429.1 151.06,71.23 v2(151.06,72.25) 151.11,72.31 U20.6
SHIPPINGMODE: length 36.9
  TOP w0.102: v2(118.8,66.93) v1(119.57,66.93)
  IN1 w0.102: v1(102.59,76.64) 102.59,75.99 102.41,75.8 102.41,74.78 104.27,72.92 104.27,72.63 105.78,71.11 107.1,71.11 108.14,70.07 108.14,69.49 108.81,68.81 108.81,67.85 108.44,67.48 108.44,65.83 v1(108.17,65.55)
  IN2 w0.102: v1(108.17,65.55) 114.81,65.55 115.37,66.11 117.6,66.11 118.43,66.93 v1(119.57,66.93)
  BOTTOM w0.102: Q38.1 v1(119.57,66.93) ; v1(102.59,76.64) 102.59,78.6 102.77,78.78 102.77,80.43 102.46,80.74 101.75,80.74 99.96,82.53 U10.18
SI: length 3.2
  BOTTOM w0.102: U11.5 111.2,68.87 110.9,69.17 110.9,70.35 R215.1
SI_EC: length 2.7
  BOTTOM w0.102: U10.102 110.98,73.14 110.95,73.11 110.95,72.17 111.15,71.97 R215.2
SLP_LAN#: length 13.5
  TOP w0.089: 38.84,70.68 38.84,70.33 37.11,68.6 37.11,68.38 36.34,67.61 36.34,66.18 35.92,65.75 35.73,65.75 35.49,65.51 35.49,63.83 v1(35.9,63.43)
  TOP w0.102: PR20.2 39.61,73.83 39.61,72.89 39.17,72.44 39.17,71.42 38.84,71.09 38.84,70.68
  BOTTOM w0.089: v1(35.9,63.43) 36.33,63.87 U1.AJ7
SLP_S3#: length 118.3
  TOP w0.102: v1(119.71,72.1) 119.71,72.92 120.12,73.32 120.12,75.18 119.55,75.74 119.55,77.86 v2(120.22,78.53) 120.63,78.94 120.63,80.26 120.26,80.62 Q11.1 ; v1(81.54,86.86) 81.54,86.83 81.07,87.3 72.09,87.3 71.65,86.86 67.05,86.86 65.85,85.67 63.4,85.67 62.68,86.39 58.88,86.39 55.87,83.38 52.71,83.38 51.29,81.96 51.29,79.16 50.4,78.27 50.4,76.5 49.41,75.51 48.47,75.51 47.12,74.16 47.12,73.78 46.6,73.26 44.01,73.26 43.82,73.07 43.82,72.53 43.58,72.3 PR22.2
  IN2 w0.102: v1(109.25,71.83) 108.96,71.83 107.3,73.49 100.37,73.49 99.19,72.31 95.53,72.31 94.82,71.59 91.8,71.59 v1(90.12,69.92)
  IN3 w0.102: v1(109.25,71.83) 109.43,71.83 109.67,72.07 117.85,72.07 118.3,72.52 119.29,72.52 v1(119.71,72.1)
  BOTTOM w0.102: U10.107 108.98,73.21 108.93,73.16 108.93,71.94 109.04,71.83 v1(109.25,71.83) 109.46,71.62 R222.1 ; v1(90.12,69.92) 89.73,69.52 89.01,69.52 88.58,69.95 88.58,72.84 85.91,75.51 83.94,75.51 81.75,77.71 81.75,81.77 83.02,83.04 83.02,84.36 82.49,84.89 82.49,85.43 81.54,86.38 v1(81.54,86.86)
SLP_S3#_R: length 8.7
  TOP w0.102: PR22.1 43.11,70.75 v1(43.07,70.71)
  BOTTOM w0.089: 39.85,68.93 39.85,68.24 40.01,68.08 40.01,67.43 40.13,67.3 40.13,67.07 40.37,66.83 40.61,66.83 40.81,66.63 40.81,66.15 U1.AT4
  BOTTOM w0.102: v1(43.07,70.71) 42.14,69.78 40.25,69.78 39.85,69.38 39.85,68.93
SLP_S4#: length 95.9
  TOP w0.102: Q10.1 114.56,72.54 v1(114.72,72.69) ; v1(91.58,72.9) 91.58,72.17 v2(91.59,72.15) 92.1,71.65 R223.1 ; PR21.2 44.31,75.67 44.25,75.61 v1(44.25,75.28)
  IN1 w0.102: v1(104.22,76.62) 104.22,76.66 104.91,77.35 108.62,77.35 111.9,74.07 113.34,74.07 v1(114.72,72.69)
  IN2 w0.102: v1(44.25,75.28) 44.24,75.28 44.26,75.27 44.27,75.27 44.88,74.66 49.93,74.66 50.41,75.14 51.65,75.14 51.97,74.82 58.24,74.82 59.18,73.88 63.39,73.88 64.51,75 66.66,75 67.26,75.61 77.32,75.61 78.21,74.72 82.48,74.72 83.2,75.45 89.53,75.45 v1(89.82,75.73)
  IN3 w0.102: v1(104.22,76.62) 103.68,77.16 102.63,77.16 102.38,77.41 100.02,77.41 98.16,75.56 96.4,75.56 94.1,73.26 91.94,73.26 v1(91.58,72.9)
  BOTTOM w0.102: U10.21 99.93,83.73 100.1,83.56 101.1,83.56 102.16,82.5 102.16,82.2 103.47,80.89 103.96,80.89 104.45,80.4 104.45,79.09 104.56,78.97 104.56,77.25 104.22,76.9 v1(104.22,76.62) ; v1(89.82,75.73) 91.3,75.73 91.54,75.5 91.54,74.87 91.78,74.63 92.04,74.63 92.28,74.39 92.28,74.06 91.58,73.36 v1(91.58,72.9)
SLP_S4#_R: length 20.4
  TOP w0.102: v1(44.25,74.65) 44.38,74.78 PR21.1
  IN2 w0.089: v1(35.9,64.71) 36.3,65.11 36.3,66.74 35.83,67.21 35.83,70.52 36.25,70.93
  IN2 w0.102: 36.25,70.93 37.38,72.07 37.38,73.6 37.62,73.84 40.17,73.84 41.12,72.89 42.49,72.89 v1(44.25,74.65)
  BOTTOM w0.089: U1.AJ6 36.11,64.52 35.92,64.71 v1(35.9,64.71)
  BOTTOM w0.102: v2(45.3,74.78) 44.38,74.78 v1(44.25,74.65)
SLP_S5#: length 166.4
  TOP w0.102: v1(112.75,75.4) 112.75,75.63 111.81,76.57 111.81,77.46 111.65,77.63 111.65,79.43 112.06,79.85 Q9.1 ; v1(157.35,78.45) 156.95,78.05 v2(156.95,77.72)
  IN2 w0.089: v1(38.91,64.49) 39.34,64.92 42.44,64.92 42.71,65.19 49.24,65.19 49.51,64.92
  IN2 w0.102: 49.51,64.92 49.75,64.92 50.15,64.52 54.82,64.52 55.34,65.04 56.19,65.04 56.28,64.95 57.34,64.95 57.59,65.2 57.59,66.56 54.01,70.13 54.01,72.34 54.96,73.28 57.14,73.28 58.23,72.2 63.61,72.2 64.03,72.62 64.03,72.68 64.65,73.3 67.5,73.3 68.69,74.49 75.87,74.49 76.66,73.7 88.86,73.7 89.07,73.49 89.6,73.49 90.76,74.65 91.19,74.65 91.6,75.06 91.6,75.22 91.86,75.48 95.56,75.48 96.11,74.93 100.13,74.93 100.47,74.59 111.94,74.59 v1(112.75,75.4) ; v1(165.1,76.5) 165.1,77.61 164.1,78.62 163.05,78.62 162.46,78.03 157.77,78.03 v1(157.35,78.45)
  IN3 w0.102: v1(112.75,75.4) 113.64,76.29 134.93,76.29 135.36,76.73 139.35,76.73 139.47,76.61 139.47,76.04 139.87,75.65 154.55,75.65 v1(157.35,78.45)
  BOTTOM w0.089: U1.AP5 39.24,64.82 v1(38.91,64.49)
  BOTTOM w0.102: Q26.1 172.98,73.96 172.7,74.24 172.44,74.24 171.76,74.92 171.76,75.61 170.66,76.7 170,76.7 169.42,76.12 167.09,76.12 166.51,76.7 166.1,76.7 165.91,76.89 165.5,76.89 v1(165.1,76.5)
SLP_SUS#: length 102.2
  TOP w0.102: v1(49,77.58) 48.34,77.58 47.97,77.21 46.72,77.21 46.28,76.76 45.46,76.76 45.17,77.06 44.4,77.06 44.02,76.67 43.89,76.67 PR24.2 ; v1(126.19,79.34) 126.42,79.57 Q8.1 ; v2(116.13,75.79) 116.13,75.28 115.65,74.79 114.86,74.79 v1(114.44,75.21) 114.44,75.81 SC6.1
  IN1 w0.102: v1(126.19,79.34) 125.77,79.76 113.14,79.76 111.65,78.27 111.65,77.64 114.07,75.21 v1(114.44,75.21)
  IN2 w0.102: v1(49,77.58) 49.06,77.58 50.18,76.46 53.37,76.46 53.64,76.73 58.4,76.73 58.65,76.47 64.42,76.47 64.67,76.73 88.63,76.73 90.04,78.13 95.97,78.13 97.12,76.98 98.14,76.98 98.98,77.82 101.97,77.82 102.35,78.2 105.55,78.2 106.19,77.56 109.03,77.56 109.37,77.22 112.97,77.22 114.44,75.75 v1(114.44,75.21)
  BOTTOM w0.102: U10.96 113.74,75.73 113.62,75.61 113.62,75.38 113.78,75.21 v1(114.44,75.21)
SLP_SUS#_R: length 12.6
  TOP w0.089: v1(40.09,66.19) 40.42,66.19 41.96,67.73 41.96,69.27 41.07,70.16 41.07,70.68
  TOP w0.102: PR24.1 43.02,74.91 43.02,74.76 v2(42.65,74.39) 42.39,74.13 41.94,74.13 41.61,73.8 41.3,73.8 41.06,73.56 41.06,70.69 41.07,70.68
  BOTTOM w0.089: U1.AP4 39.76,65.85 v1(40.09,66.19)
SLP_WLAN#: length 151.6
  TOP w0.102: PR220.1 47.04,79.09 SR97.2 48.74,79.09 49.02,79.37 49.02,82.81 49.49,83.28 51.75,83.28 52.46,83.99 55.62,83.99 58.63,87 64.59,87 64.88,86.71 66.03,86.71 66.8,87.47 71.4,87.47 71.84,87.91 82.51,87.91 83.01,87.42 83.01,85.89 83.53,85.37 83.53,84.82 82.87,84.17 v1(82.6,84.17)
  IN2 w0.102: v1(110.85,84.38) 110.42,83.96 105.95,83.96 105.76,83.77 96.61,83.77 95.91,84.47 94.12,84.47 93.37,83.72 88.52,83.72 87.91,83.11 85.74,83.11 85.64,83.01 83.76,83.01 v1(82.6,84.17)
  IN3 w0.102: v1(110.85,84.38) 110.85,83.84 111.29,83.39 128.95,83.39 129.72,84.16 131.93,84.16 133.63,85.87 139.63,85.87 143.08,82.41 146.23,82.41 146.99,81.66 163.72,81.66 165.95,79.43 165.95,76.69 v1(165.74,76.47)
  BOTTOM w0.102: Q25.1 169.73,73.91 169.72,73.91 v2(169.72,74.85) 169.72,75.05 168.86,75.91 167.01,75.91 166.45,76.47 v1(165.74,76.47) ; U10.81 111.4,81.73 110.85,82.29 v1(110.85,84.38)
SLP_WLAN_R: length 23.4
  TOP w0.089: v1(37.61,65.35) 38.01,65.75 38.94,65.75 39.42,66.23 39.42,66.87 40.92,68.37 40.92,69.54 40.86,69.6 40.86,71.57
  TOP w0.102: v2(48.44,80.33) 48.06,79.95 46.84,79.95 46.53,79.65 46.53,78.7 PR220.2 46.68,77.84 46.43,77.84 46.23,77.64 44.94,77.64 44.56,77.26 44.32,77.26 43.99,76.93 43.23,76.93 43.05,76.75 43.05,76.19 42.9,76.04 42.9,75.39 41.6,74.08 41.29,74.08 40.86,73.65 40.86,71.57
  BOTTOM w0.089: U1.AM5 37.94,65.02 v1(37.61,65.35)
SM_DRAMRST#: length 123.7
  TOP w0.089: v1(42.15,59.56) 42.15,58.95 41.83,58.64 41.83,55.99 42.66,55.16 43.58,55.16 44.69,54.05 45.98,54.05 46.41,54.47 48.16,54.47
  TOP w0.102: v1(88.8,22.14) 88.61,21.95 R39.1 ; 48.16,54.47 48.2,54.44 52.17,54.44 53.16,55.43 53.16,57.08 54.87,58.79 56.84,58.79 58.66,60.61 58.66,69.76 59.68,70.78 59.68,71.74 60.13,72.2 62.59,72.2 62.87,72.47 62.87,72.73 63.24,73.1 64.42,73.1 64.5,73.02 66.76,73.02 68.15,74.41 76.62,74.41 77.37,73.66 79.85,73.66 80.58,74.39 86.32,74.39 87.96,72.75 89.22,72.75 90.81,71.17 90.81,68.42 92.56,66.67 92.56,42 v2(91.8,41.24) 90.76,40.2 90.76,39.41 v1(89.13,37.79)
  BOTTOM w0.089: v1(42.15,59.56) 42.12,59.54 42.12,59.43 U1.AV15
  BOTTOM w0.102: v1(89.13,37.79) 89.13,37.43 89.22,37.34 89.22,27.56 88.8,27.14 v1(88.8,22.14)
SM_INTRUDER#: length 15.2
  TOP w0.089: R73.2 47.63,68.8 47,68.17 46.53,68.17 45.31,66.95 44.78,66.95 42.57,64.74 42.57,63.91 42.31,63.65 41.92,63.65 41.67,63.91 v1(41.51,64.06)
  BOTTOM w0.089: T2.1 46.13,64.99 43.83,64.99 43.56,64.72 42.16,64.72 42.11,64.77 41.49,64.77 U1.AU6 41.19,64.38 v1(41.51,64.06)
SM_RCOMP_0: length 11.5
  TOP w0.089: v1(40.26,31.41) 40.27,31.42 41.05,31.42 42.24,30.23 43.47,30.23 45.59,28.12 v2(45.59,25.9) HR7.1
  BOTTOM w0.089: U1.AU60 41.01,31.42 40.27,31.42 v1(40.26,31.41)
SM_RCOMP_1: length 9.9
  TOP w0.089: v1(44.78,29.96) 46.75,27.99 v2(46.75,27.37) HR8.1
  BOTTOM w0.089: v1(44.78,29.96) 44.15,29.96 43.68,30.43 43.38,30.73 42.77,30.73 42.6,30.9 42.18,30.9 U1.AV60
SM_RCOMP_2: length 9.1
  TOP w0.089: HR9.1 v2(44.35,27.6) 44.35,28.08 42.7,29.74 42.02,29.74 v1(40.73,31.02)
  BOTTOM w0.089: U1.AU61 40.73,30.71 v1(40.73,31.02)
SMB0_CLK_C: length 10.7
  TOP w0.102: v1(128.98,77.94) 128.98,78.2 T44.1
  BOTTOM w0.102: L9.1 130.18,69.77 130.15,69.8 C160.1 130.15,70.87 129.93,71.09 D22.1 129.93,72.04 130.01,72.11 CON8.3 130.01,77.73 129.8,77.94 v1(128.98,77.94)
SMB0_DAT_C: length 10.8
  TOP w0.102: T43.1 128.3,76.75 v1(128.3,77.92)
  BOTTOM w0.102: L10.1 127.9,69.66 127.79,69.77 C159.1 127.79,70.83 127.9,70.95 D21.1 128.51,72.06 CON8.4 128.51,77.72 v1(128.3,77.92)
SMB_CLK_M_MINI0: length 11
  TOP w0.102: D14.1 176.81,62.48 176.14,62.48 R305.2 175.83,62.77 175.36,62.3 174.99,62.3 173.9,61.21 v2(173.9,60.55) 174,60.44 R309.1 174.5,59.38 v1(174.7,59.17)
  BOTTOM w0.102: CONWIFI.60 173.94,56.6 174.07,56.74 174.07,58.54 v1(174.7,59.17)
SMB_CLK_M_MSATA0: length 4.8
  TOP w0.102: v2(106.3,19.37) 105.43,18.5 105.25,18.5 v1(104.83,18.08) 104.06,18.85 R281.1
  BOTTOM w0.102: CONSATA.58 v1(104.83,18.08)
