# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQ12: length 45.5
  TOP w0.102: U2.C3 73.58,23.8 v1(73.98,23.41)
  IN1 w0.089: v1(38.81,26.66) 40.18,25.29 46.86,25.29 47.07,25.09
  IN1 w0.229: 47.07,25.09 48.67,23.49 52.44,23.49 53.37,22.56 57.52,22.56 59.56,20.52 69.04,20.52 69.39,20.87 72.56,20.87 72.89,21.2 72.89,22.74 73.07,22.93 73.51,22.93 73.98,23.4 v1(73.98,23.41)
  BOTTOM w0.089: v2(38.28,26.15) 38.52,26.4 38.55,26.4 v1(38.81,26.66) 38.04,27.44 38.04,28.84 37.94,28.94 37.94,29.95 38.17,30.18 38.17,30.32 U1.AM61
M_CHA_DQ13: length 46.4
  TOP w0.089: v1(38.98,27.8) 39.41,28.22 v2(39.63,28.22)
  TOP w0.102: U2.C2 73.98,22.61 v1(73.98,22.61)
  IN1 w0.089: 46.66,24.81 46.43,25.04 39.87,25.04 38.41,26.5 38.41,27.23 v1(38.98,27.8)
  IN1 w0.229: v1(73.98,22.61) 73.31,21.93 73.31,21.02 72.74,20.45 69.62,20.45 69.27,20.1 59.39,20.1 57.34,22.14 53.19,22.14 52.27,23.07 48.4,23.07 46.66,24.81
  BOTTOM w0.089: v1(38.98,27.8) 38.98,27.81 38.57,28.22 38.57,28.67 38.69,28.79 38.69,29.28 38.61,29.44 38.61,30.33 38.63,30.35 38.63,30.61 38.33,30.91 U1.AM60
M_CHA_DQ14: length 40.7
  TOP w0.102: v1(73.98,28.21) 73.98,28.21 U2.C8
  IN1 w0.089: 49.81,28.14 42.12,28.14 v1(41.45,27.47)
  IN1 w0.229: 49.81,28.14 51.96,28.14 54.59,25.51 58.94,25.51 59.3,25.15 66.24,25.15 69.12,28.03 73.8,28.03 v1(73.98,28.21)
  BOTTOM w0.089: v1(41.45,27.47) 41.25,27.47 40.84,27.88 40.5,27.88 40.09,28.29 40.09,28.88 40.04,28.94 40.04,29.69 39.9,29.83 39.9,30.15 U1.AP61
  BOTTOM w0.102: v1(73.98,28.21) v2(73.26,28.21)
M_CHA_DQ15: length 40.7
  TOP w0.102: v1(72.37,29.05) 72.37,28.22 U2.B8
  IN1 w0.089: v1(41.25,28.08) 42.39,29.23 42.75,29.23 43.38,28.59 49.81,28.59
  IN1 w0.229: 49.81,28.59 52.1,28.59 54.22,26.48 58.57,26.48 59.48,25.57 66.07,25.57 68.95,28.45 71.77,28.45 v1(72.37,29.05)
  BOTTOM w0.089: U1.AP60 39.57,30.9 40.09,30.38 40.23,30.38 40.68,29.93 40.68,28.83 40.92,28.59 40.92,28.41 v1(41.25,28.08)
  BOTTOM w0.102: v2(72.54,29.89) 72.37,29.71 v1(72.37,29.05)
M_CHA_DQ16: length 44.3
  TOP w0.102: v1(73.61,32.99) 74.04,33.41 74.04,33.88 74.04,33.89 74.04,33.9 74.25,34.12 75.25,34.12 75.52,34.39 75.52,34.68 75.18,35.03 U3.E3
  IN1 w0.089: v1(39.82,31.83) 39.82,31.28 40.73,30.37 46.64,30.37 47.04,29.96 49.81,29.96
  IN1 w0.229: v1(73.61,32.99) 73.15,32.53 71.05,32.53 66.11,27.58 61.94,27.58 61.36,28.16 59.13,28.16 58.54,28.76 54.66,28.76 53.45,29.96 49.81,29.96
  BOTTOM w0.089: U1.AP58 39.38,32.27 v1(39.82,31.83)
  BOTTOM w0.102: v2(72.32,32.4) 73.03,32.4 v1(73.61,32.99)
M_CHA_DQ17: length 46.1
  TOP w0.102: U3.H3 77.24,35 77.24,33.18 76.82,32.76 76.3,32.76 76.09,32.54 75.87,32.54 75.48,32.15 v1(75.48,31.72)
  IN1 w0.089: 49.81,30.57 48.59,30.57 48.59,30.57 41.92,30.57 v1(40.43,32.07)
  IN1 w0.229: v1(75.48,31.72) 75.03,32.17 75.03,32.17 74.09,33.11 74.09,33.19 74.03,33.25 74.03,33.26 73.66,33.62 70.89,33.62 70.64,33.37 70.64,32.71 66.51,28.58 59.47,28.58 58.87,29.19 54.82,29.19 53.44,30.57 49.81,30.57
  BOTTOM w0.089: v1(40.43,32.07) 40.23,32.27 40.16,32.27 U1.AR58
  BOTTOM w0.102: v2(75.36,32.5) 75.36,31.83 v1(75.48,31.72)
M_CHA_DQ18: length 46.1
  TOP w0.102: v1(75.59,37.41) 76.05,37.86 76.05,38.48 U3.F7
  IN1 w0.089: v1(37.76,32.8) 38.36,33.4 38.65,33.4 38.68,33.43 42.73,33.43 43.05,33.75 49.81,33.75
  IN1 w0.229: v1(75.59,37.41) 75.31,37.41 74.98,37.08 71.6,37.08 70.74,36.21 68.49,36.21 67.21,34.94 67.21,33.57 66.68,33.04 66.35,33.04 64,30.69 60.55,30.69 59.37,31.87 58.95,31.87 58.72,32.1 56.82,32.1 55.17,33.75 49.81,33.75
  BOTTOM w0.089: v1(37.76,32.8) 37.76,32.97 U1.AM57
  BOTTOM w0.102: v1(75.59,37.41) 75.97,37.03 v2(75.97,36.52)
M_CHA_DQ19: length 49.3
  TOP w0.102: U3.F8 75.64,39 75.64,38.08 v1(75.63,38.07)
  IN1 w0.089: 49.81,34.17 47.51,34.17 47.27,33.93 43.76,33.93 42.78,34.92 40.59,34.92 39.99,34.32 36.99,34.32 36.5,33.83 v1(36.5,32.85)
  IN1 w0.229: 49.81,34.17 55.35,34.17 56.66,32.86 58.56,32.86 59.12,32.3 59.53,32.3 60.72,31.11 63.83,31.11 66.18,33.46 66.51,33.46 66.79,33.74 66.79,35.11 68.31,36.63 70.52,36.63 71.3,37.41 72.67,37.41 73.66,38.4 75.33,38.4 75.63,38.09 v1(75.63,38.07)
  BOTTOM w0.089: U1.AK57 36.77,33.3 36.5,33.02 v1(36.5,32.85)
  BOTTOM w0.102: v1(75.63,38.07) 75.52,38.18 v2(75.52,39.01)
M_CHA_DQ20: length 45.5
  TOP w0.102: v1(73.92,32.43) 74.61,32.43 75.19,33 75.19,33.26 75.52,33.6 75.52,33.81 75.98,34.27 U3.F2
  IN1 w0.089: 48.08,29.54 44.1,29.54 43.62,30.02 39.49,30.02 38.15,31.36 37.92,31.36 37.71,31.58 v1(37.71,31.97)
  IN1 w0.229: v1(73.92,32.43) 73.92,32.39 73.67,32.15 71.27,32.15 66.28,27.16 61.77,27.16 61.5,27.43 54.61,27.43 52.49,29.54 48.08,29.54
  BOTTOM w0.089: U1.AL58 37.43,32.24 v1(37.71,31.97)
  BOTTOM w0.102: v2(73.79,31.49) 73.79,32.3 v1(73.92,32.43)
M_CHA_DQ21: length 48.5
  TOP w0.089: v1(36.47,31.97) 36.15,32.3 v2(35.46,32.3)
  TOP w0.102: U3.G2 76.32,34.09 76.32,33.54 76.13,33.35 76.13,32.99 75.89,32.75 75.79,32.75 75.02,31.97 v1(74.55,31.97)
  IN1 w0.089: 43.31,29.13 42.71,29.73 39.42,29.73 38.02,31.13 37.32,31.13 v1(36.47,31.97)
  IN1 w0.229: v1(74.55,31.97) 74.53,31.97 74.35,31.79 71.5,31.79 65.81,26.1 59.95,26.1 59.04,27.01 54.44,27.01 52.32,29.13 43.31,29.13
  BOTTOM w0.089: v1(36.47,31.97) 36.6,32.11 36.6,32.22 U1.AK58
M_CHA_DQ22: length 45.3
  TOP w0.102: v1(76.58,37.23) 76.61,37.23 77.58,38.2 U3.H7
  IN1 w0.089: v1(39.69,32.85) 43.69,32.85 43.85,32.68 46.61,32.68 46.86,32.94 47.55,32.94 47.8,32.68 49.81,32.68
  IN1 w0.229: 49.81,32.68 55.06,32.68 56.48,31.26 58.38,31.26 58.62,31.02 58.94,31.02 60.11,29.85 64.35,29.85 66.7,32.2 67.03,32.2 68.05,33.22 68.05,34.43 69,35.37 71.25,35.37 71.63,35.76 74.78,35.76 75.54,36.52 75.85,36.52 76.4,37.07 76.4,37.08 76.56,37.23 v1(76.58,37.23)
  BOTTOM w0.089: v1(39.69,32.85) 39.69,32.96 U1.AR57
  BOTTOM w0.102: v1(76.58,37.23) 76.91,37.56 77.12,37.56 v2(77.27,37.71)
M_CHA_DQ23: length 48.3
  TOP w0.102: v1(76.58,37.91) 76.71,37.91 77.19,38.4 77.19,38.7 77.58,39.09 U3.H8
  IN1 w0.089: 49.81,33.1 47.95,33.1 47.48,33.57 43.13,33.57 42.81,33.25 38.85,33.25 v1(38.44,32.84)
  IN1 w0.229: v1(76.58,37.91) 76.46,37.91 76.07,37.53 76.07,37.21 75.72,36.85 75.34,36.85 74.58,36.09 71.35,36.09 71.06,35.79 68.66,35.79 67.63,34.76 67.63,33.39 66.86,32.62 66.53,32.62 64.18,30.27 60.35,30.27 59.18,31.44 58.79,31.44 58.55,31.68 56.65,31.68 55.23,33.1 49.81,33.1
  BOTTOM w0.089: U1.AN57 38.44,33.01 v1(38.44,32.84)
  BOTTOM w0.102: v2(77.24,39.46) 77.22,39.44 77.22,38.55 v1(76.58,37.91)
M_CHA_DQ24: length 42.7
  TOP w0.102: U3.A7 71.98,38.06 v1(71.81,37.89)
  IN3 w0.089: 49.99,28.57 49.13,28.57 48.74,28.95 44.26,28.95 43.08,30.13 43.08,30.42 42.36,31.14 42.14,31.14 40.02,33.26 39.64,33.26 v1(39.08,33.83)
  IN3 w0.178: v1(71.81,37.89) 71.32,37.89 70.05,36.62 68.36,36.62 68.02,36.27 68.02,35 66.12,33.11 65.84,33.11 65.53,33.42 65.18,33.42 64.78,33.02 64.78,32.26 63.32,30.79 61.32,30.79 59.24,28.71 53.95,28.71 53.81,28.57 49.99,28.57
  BOTTOM w0.089: U1.AP55 39.23,34.09 39.23,33.98 v1(39.08,33.83)
  BOTTOM w0.102: v1(71.81,37.89) 71.32,37.89 v2(70.94,38.27)
M_CHA_DQ25: length 44.1
  TOP w0.102: v1(72.47,37.89) 72.47,38.27 72.44,38.3 72.44,39 U3.B8
  IN3 w0.089: 49.32,28.94 49.1,29.15 44.31,29.15 43.46,30 43.46,30.34 42.49,31.32 42.24,31.32 v1(39.72,33.83)
  IN3 w0.178: 49.32,28.94 53.66,28.94 53.8,29.08 59.08,29.08 61.17,31.16 62.1,31.16 62.31,31.36 62.31,32.22 63.1,33.02 63.46,33.02 65.11,34.68 66.79,34.68 67.64,35.53 67.64,36.42 68.21,36.98 69.9,36.98 71.26,38.35 72.26,38.35 72.47,38.14 v1(72.47,37.89)
  BOTTOM w0.089: v1(39.72,33.83) 39.89,33.99 39.89,34.1 U1.AR55
  BOTTOM w0.102: v1(72.47,37.89) 72.37,37.99 v2(72.37,39.57)
M_CHA_DQ26: length 48.1
  TOP w0.102: v1(73.18,34.94) 73.18,34.94 U3.C2
  IN3 w0.089: v1(38.39,34.73) 37.98,34.32 37.58,34.32 37.41,34.15 37.41,33.59 36.9,33.08 36.9,31.7 38.67,29.93 42.08,29.93 44.26,27.75 44.48,27.75
  IN3 w0.178: v1(73.18,34.94) 72.07,34.94 71.67,35.35 70.4,35.35 69.42,34.37 68.96,34.37 66.49,31.89 66,31.89 63.78,29.67 61.78,29.67 58.93,26.82 53.03,26.82 52.57,27.28 48.73,27.28 48.26,27.75 44.48,27.75
  BOTTOM w0.089: v1(38.39,34.73) 38.08,35.04 U1.AM54
  BOTTOM w0.102: v1(73.18,34.94) 73.05,34.82 v2(73.05,33.98)
M_CHA_DQ27: length 49.8
  TOP w0.102: v1(71.48,34.89) 71.63,34.89 U3.A2
  IN3 w0.089: 44.32,27.02 43.28,28.06 42.36,28.06 40.87,29.55 37.2,29.55 35.36,31.39 35.36,32.53 36.12,33.3 36.12,33.71 36.76,34.34 36.76,35.54 v1(36.58,35.71)
  IN3 w0.178: 44.32,27.02 48.11,27.02 49.24,25.89 52.33,25.89 52.68,25.54 58.69,25.54 62.07,28.92 64.12,28.92 66.36,31.16 66.8,31.16 69.27,33.63 69.73,33.63 70.53,34.43 71.02,34.43 v1(71.48,34.89)
  BOTTOM w0.089: U1.AK54 36.78,35.51 v1(36.58,35.71)
  BOTTOM w0.102: v1(71.48,34.89) 71.22,34.64 v2(71.22,33.85)
M_CHA_DQ28: length 48.7
  TOP w0.102: v1(70.77,34.89) 71.22,35.34 U3.A3
  IN3 w0.089: v1(37.77,34.72) 37.39,34.72 36.3,33.63 36.3,33.23 35.53,32.46 35.53,31.46 37.24,29.75 41.95,29.75 44.33,27.37
  IN3 w0.102: 70.75,34.88 v1(70.77,34.89)
  IN3 w0.178: 44.33,27.37 48.13,27.37 48.59,26.92 52.35,26.92 52.66,26.61 52.66,26.26 52.91,26 54.05,26 54.5,26.45 59.08,26.45 61.93,29.3 63.93,29.3 66.16,31.53 66.64,31.53 69.12,34 69.57,34 70.46,34.88 70.75,34.88
  BOTTOM w0.089: U1.AL55 37.43,34.37 v1(37.77,34.72)
  BOTTOM w0.102: v1(70.77,34.89) 71.12,35.25 v2(71.12,35.6)
M_CHA_DQ29: length 51.1
  TOP w0.102: U3.C3 73.58,35.34 v1(73.98,34.94)
  IN3 w0.089: v1(36.34,34.53) 36.34,34.52 35.92,34.1 35.92,33.35 35.18,32.61 35.18,31.31 37.12,29.37 40.8,29.37 42.29,27.88 43.14,27.88 44.36,26.66
  IN3 w0.178: 44.36,26.66 48.09,26.66 49.23,25.52 52.17,25.52 52.53,25.17 58.84,25.17 62.22,28.55 65.05,28.55 69.77,33.26 70.3,33.26 71.3,34.26 73.29,34.26 v1(73.98,34.94)
  BOTTOM w0.089: U1.AK55 36.5,34.53 v1(36.34,34.53)
  BOTTOM w0.102: v2(73.61,35.65) 73.61,35.31 v1(73.98,34.94)
M_CHA_DQ30: length 46.5
  TOP w0.089: v2(41,34.59) 40.86,34.73 v1(39.74,34.73)
  TOP w0.102: v1(75.03,37.85) 74.73,38.16 74.73,38.19 U3.D7
  IN3 w0.089: v1(39.74,34.73) 40.53,34.73 41.25,34 41.25,33.21 43.98,30.48 45.33,30.48 45.92,29.89 49.56,29.89 49.77,29.67 49.99,29.67
  IN3 w0.178: 49.99,29.67 53.35,29.67 53.49,29.81 58.78,29.81 60.57,31.6 60.57,32.26 61.05,32.75 61.36,32.75 61.45,32.75 62.17,33.47 62.17,34.18 62.75,34.77 63.49,34.77 64.14,35.42 66.49,35.42 66.75,35.68 66.75,36.57 67.9,37.72 69.59,37.72 70.96,39.08 73.84,39.08 75.06,37.86 75.05,37.85 v1(75.03,37.85)
  BOTTOM w0.089: v1(39.74,34.73) 39.74,34.9 U1.AR54
M_CHA_DQ31: length 46.8
  TOP w0.102: v1(74.31,37.76) 73.92,38.15 73.92,39 U3.C8
  IN3 w0.089: 49.99,29.3 49.45,29.3 49.33,29.43 44.69,29.43 41.05,33.07 41.05,33.82 40.55,34.33 39.42,34.33 39.02,34.73 v1(39.02,34.73)
  IN3 w0.178: 49.99,29.3 53.5,29.3 53.65,29.45 58.93,29.45 60.94,31.45 60.94,32.11 61.2,32.38 61.58,32.38 61.59,32.37 62.54,33.32 62.54,34.03 62.91,34.4 63.64,34.4 64.29,35.05 66.64,35.05 67.12,35.53 67.12,36.42 68.06,37.35 69.75,37.35 71.11,38.71 73.34,38.71 74.3,37.76 v1(74.31,37.76)
  BOTTOM w0.089: U1.AN54 38.73,35.02 39.02,34.73 v1(39.02,34.73)
  BOTTOM w0.102: v2(73.91,38.35) 73.91,38.17 v1(74.31,37.76)
M_CHA_DQ32: length 47.3
  TOP w0.089: v2(47.5,30.37) 47.19,30.37 v1(46.55,31.02)
  TOP w0.102: U4.F2 76.38,54.75 v1(76.38,54.75)
  IN3 w0.089: v1(46.55,31.02) 46.67,30.89 49.99,30.89
  IN3 w0.178: 49.99,30.89 52.2,30.89 60.66,39.35 61.8,39.35 64.64,42.18 66.76,42.18 67.16,42.58 67.16,43.01 71.97,47.82 71.97,48.03 75.52,51.58 75.52,52.42 75.74,52.65 75.74,54.12 v1(76.38,54.75)
  BOTTOM w0.089: v1(46.55,31.02) 46.02,31.55 44.39,31.55 43.67,32.27 43.24,32.27 U1.AY58
M_CHA_DQ33: length 47.9
  TOP w0.102: U4.G2 76.38,53.95 v1(76.38,53.95)
  IN3 w0.089: 49.99,30.52 46.43,30.52 v1(45.94,31.02)
  IN3 w0.178: v1(76.38,53.95) 76.13,53.7 76.13,52.54 75.9,52.32 75.9,51.45 72.34,47.88 72.34,47.66 67.53,42.86 67.53,42.43 66.92,41.81 65.39,41.81 65.04,41.46 65.04,40.42 62.41,37.79 59.62,37.79 52.36,30.52 49.99,30.52
  BOTTOM w0.089: U1.AW58 42.79,32.07 43.02,32.07 43.02,32.07 43.37,32.07 43.37,32.07 43.54,32.07 44.24,31.37 45.58,31.37 v1(45.94,31.02)
  BOTTOM w0.102: v1(76.38,53.95) 75.76,53.95 v2(75.67,54.04)
M_CHA_DQ34: length 49.9
  TOP w0.102: U4.F8 75.98,59.24 75.67,59.55 v1(75.58,59.55)
  IN3 w0.089: v1(45.85,33.17) 46.25,33.57 49.9,33.57 49.99,33.48
  IN3 w0.102: 70.82,53.26 70.82,53.34 70.83,53.36
  IN3 w0.178: v1(75.58,59.55) 75.12,59.1 73.18,59.1 71.96,57.88 71.96,57.04 71.58,56.66 71.58,55.17 70.83,54.43 70.83,53.36 ; 70.82,53.26 70.56,53 69.5,53 68.54,52.04 68.54,50.99 66.33,48.79 65.28,48.79 64.73,48.23 64.73,47.49 62.69,45.45 62.69,44.56 61.96,43.83 60.75,43.83 59.81,42.9 59.81,42.17 51.13,33.48 49.99,33.48
  BOTTOM w0.089: U1.AY56 43.29,33.87 45.15,33.87 v1(45.85,33.17)
  BOTTOM w0.102: v1(75.58,59.55) 75.02,59 v2(74.32,59)
M_CHA_DQ35: length 50.3
  TOP w0.102: U4.F7 75.98,58.43 75.66,58.75 v1(75.58,58.75)
  IN3 w0.089: v1(46.46,33.17) 46.47,33.19 49.92,33.19 49.99,33.12
  IN3 w0.178: v1(75.58,58.75) 73.23,58.75 72.24,57.76 72.24,56.92 71.86,56.54 71.86,54.93 71.2,54.27 71.2,52.71 69.11,50.62 69.1,50.62 66.9,48.42 65.44,48.42 65.1,48.08 65.1,47.34 63.06,45.29 63.06,44.4 62.12,43.46 60.9,43.46 60.18,42.75 60.18,42.01 54.92,36.75 51.28,33.12 49.99,33.12
  BOTTOM w0.089: U1.AW56 42.72,33.72 43.05,34.05 45.88,34.05 46.46,33.47 v1(46.46,33.17)
  BOTTOM w0.102: v1(75.58,58.75) 75.12,58.3 v2(75.12,57.46)
M_CHA_DQ36: length 53.8
  TOP w0.102: U4.H7 77.58,58.19 76.58,57.19 v1(76.58,57.01)
  IN3 w0.089: 49.99,32.38 49.77,32.6 48.47,32.6 48.23,32.83 46.93,32.83 46.7,32.6 45.19,32.6 44.62,33.16 v1(44.61,33.16)
  IN3 w0.178: 49.99,32.38 49.99,32.38 51.59,32.38 60.04,40.83 61.11,40.83 63.79,43.52 63.79,44.95 65.88,47.05 66.57,47.05 71.93,52.41 71.93,53.93 75.53,57.52 75.92,57.52 76.43,57.01 v1(76.58,57.01)
  BOTTOM w0.089: v1(44.61,33.16) 44.27,33.51 43.81,33.51 43.55,33.25 43.03,33.25 43.02,33.26 42.98,33.28 42.88,33.33 42.75,33.33 42.6,33.25 42.38,33.25 42.2,33.34 42,33.34 41.97,33.31 41.67,33.31 41.65,33.34 41.39,33.34 41.22,33.17 41.22,32.92 41.48,32.66 41.55,32.66 U1.AV58
  BOTTOM w0.102: v2(77.15,57.93) 76.83,57.93 76.65,58.11 76.31,58.11 76.06,57.86 76.06,57.51 76.31,57.27 76.33,57.27 v1(76.58,57.01)
M_CHA_DQ37: length 53.6
  TOP w0.089: v1(45.3,30.97) 45.62,30.65 v2(45.62,30.14)
  TOP w0.102: v1(77.01,56.51) 77.58,55.94 U4.H3
  IN3 w0.089: v1(45.3,30.97) 46.11,30.15 49.99,30.15
  IN3 w0.178: v1(77.01,56.51) 76.84,56.33 76.84,53.51 76.93,53.41 76.93,51.95 72.7,47.73 72.7,47.51 71.57,46.37 71.57,45.94 63.04,37.42 59.77,37.42 52.51,30.15 49.99,30.15
  BOTTOM w0.089: U1.AU58 41.37,32.19 41.6,32.19 41.72,32.07 41.97,32.07 42,32.1 42.29,32.1 42.81,31.59 42.81,31.58 43,31.38 43.37,31.38 44.18,30.57 44.9,30.57 v1(45.3,30.97)
M_CHA_DQ38: length 50.1
  TOP w0.102: U4.H8 77.45,59.15 77.05,58.75 v1(76.38,58.75)
  IN3 w0.089: v1(45.23,33.16) 45.62,32.77 46.62,32.77 46.86,33.01 48.3,33.01 48.54,32.77 49.96,32.77 49.99,32.75
  IN3 w0.178: v1(76.38,58.75) 76.27,58.75 71.57,54.06 71.57,52.56 69.26,50.25 69.25,50.25 66.41,47.41 65.73,47.41 63.42,45.11 63.42,44.06 61.91,42.55 61.24,42.55 59.14,40.45 51.44,32.75 49.99,32.75
  BOTTOM w0.089: U1.AV56 42.09,33.61 42.12,33.58 42.43,33.43 42.56,33.43 42.71,33.51 42.92,33.51 43.05,33.45 43.08,33.43 43.45,33.43 43.7,33.69 44.7,33.69 v1(45.23,33.16)
  BOTTOM w0.102: v1(76.38,58.75) 76.38,59.48 v2(76.71,59.81)
M_CHA_DQ39: length 49.7
  TOP w0.089: v2(42.62,33.47) v1(42.62,34.31)
  TOP w0.102: v1(75.58,54.75) 75.58,54.76 U4.E3
  IN3 w0.089: 49.99,31.26 47.32,31.26 47.14,31.44 45.1,31.44 42.62,33.92 v1(42.62,34.31)
  IN3 w0.178: v1(75.58,54.75) 75.31,54.75 75.13,54.58 75.13,52.56 74.88,52.31 74.88,51.47 74.69,51.27 73.91,51.27 73.78,51.15 73.78,50.37 71.6,48.18 71.6,47.97 66.79,43.16 66.79,42.82 66.53,42.55 64.48,42.55 61.65,39.72 60.51,39.72 52.05,31.26 49.99,31.26
  BOTTOM w0.089: v1(42.62,34.31) 42.27,33.96 41.54,33.96 U1.AU56
M_CHA_DQ40: length 42.9
  TOP w0.191: U4.A2 70.79,54.35 69.82,55.32 v1(69.82,56.66)
  IN3 w0.089: 49.99,35.07 48.45,35.07 48.42,35.11 45.17,35.11 44.51,34.45 v1(44.47,34.45)
  IN3 w0.178: v1(69.82,56.66) 69.82,56.37 69.28,55.83 69.02,55.83 66.42,53.23 66.42,51.87 65.6,51.05 64.47,51.05 63.15,49.73 63.15,48.52 62.08,47.45 61.02,47.45 59.37,45.8 59.37,44.7 58.23,43.56 58.23,42.82 50.47,35.07 49.99,35.07
  BOTTOM w0.089: U1.AY54 43.26,34.92 44.14,34.92 44.47,34.59 v1(44.47,34.45)
M_CHA_DQ41: length 45.5
  TOP w0.089: v2(43.54,35.2) 43.54,34.78 v1(43.86,34.46)
  TOP w0.102: U4.C3 73.58,56.05 72.98,56.66 v1(71.1,56.66)
  IN3 w0.089: 49.99,34.34 48.72,34.34 48.55,34.17 47.57,34.17 47.45,34.05 44.3,34.05 43.89,34.46 v1(43.86,34.46)
  IN3 w0.178: 49.99,34.34 50.78,34.34 58.96,42.52 58.96,43.25 60.11,44.4 60.11,45.09 60.73,45.71 61.75,45.71 62.02,45.98 63.88,47.84 63.88,49.42 64.77,50.31 65.9,50.31 66.33,50.74 67.16,51.57 67.16,52.92 69.33,55.09 69.89,55.09 71.1,56.31 v1(71.1,56.66)
  BOTTOM w0.089: v1(43.86,34.46) 43.06,34.46 42.72,34.8 U1.AW54
M_CHA_DQ42: length 45.8
  TOP w0.102: 72.51,61.09 72.81,60.8 72.81,60.47 73.12,60.16 73.12,59.61 U4.C8
  TOP w0.191: 72.51,61.09 70.74,61.09 v1(70.46,60.81)
  IN3 w0.089: v1(45.49,36.92) 46.37,36.92
  IN3 w0.178: 46.37,36.92 46.38,36.91 47.88,36.91 48.33,37.36 48.94,37.36 55.45,43.86 55.45,44.52 58.94,48.01 58.94,49.96 60.43,51.46 60.43,52.54 60.99,53.1 61.19,53.1 62.48,54.4 62.48,54.47 64.54,56.53 66.42,56.53 67.07,57.18 67.07,58.16 69.08,60.16 70.13,60.16 70.46,60.49 v1(70.46,60.81)
  BOTTOM w0.089: U1.AY52 43.87,36.15 43.97,36.26 44.83,36.26 v1(45.49,36.92)
  BOTTOM w0.191: v1(70.46,60.81) 70.69,61.04 v2(70.69,61.49)
M_CHA_DQ43: length 45.6
  TOP w0.102: v1(71.53,58.83) 71.62,58.83 71.75,58.7 74.04,58.7 U4.D7
  IN3 w0.089: v1(44.88,36.92) 45.28,36.52 46.27,36.52 46.4,36.65
  IN3 w0.102: 70.8,59.25 71.1,59.25 v1(71.53,58.83)
  IN3 w0.178: 46.4,36.65 48.05,36.65 48.39,36.99 49.19,36.99 55.82,43.62 55.82,44.37 59.3,47.85 59.3,49.81 60.8,51.31 60.8,52.3 61.24,52.73 61.53,52.73 63.22,54.42 64.83,54.42 67.44,57.03 67.44,57.87 68.82,59.25 70.8,59.25
  BOTTOM w0.089: v1(44.88,36.92) 44.39,36.43 43.08,36.43 42.85,36.33 U1.AW52
  BOTTOM w0.102: v1(71.53,58.83) 71.25,58.55 v2(71.25,58.16)
M_CHA_DQ44: length 46.6
  TOP w0.089: v2(45.72,34.79) 45.42,34.79 v1(45.08,34.45)
  TOP w0.102: 73.23,55.4 73.23,54.71 U4.C2
  TOP w0.191: v1(70.46,56.67) 70.64,56.49 70.64,56.47 70.98,56.13 72.5,56.13 73.23,55.4
  IN3 w0.089: 49.99,34.7 49.8,34.89 45.52,34.89 v1(45.08,34.45)
  IN3 w0.178: v1(70.46,56.67) 70.46,56.49 69.43,55.46 69.18,55.46 66.79,53.08 66.79,51.72 65.96,50.89 65.75,50.68 64.62,50.68 64.31,50.37 63.51,49.57 63.51,48.36 62.23,47.08 61.18,47.08 59.74,45.64 59.74,44.55 58.59,43.4 58.59,42.67 50.63,34.7 49.99,34.7
  BOTTOM w0.089: U1.AV54 42.11,35.17 42.94,35.17 43.03,35.26 43.75,35.26 43.91,35.1 44.67,35.1 45.08,34.69 v1(45.08,34.45)
M_CHA_DQ45: length 43.2
  TOP w0.102: v1(71.12,55.36) 71.77,55.36 U4.A3
  IN3 w0.089: 49.99,33.97 49.67,33.97 49.58,33.87 43.76,33.87 42.88,34.75 42.35,34.75 v1(42,34.4)
  IN3 w0.178: v1(71.12,55.36) 71.08,55.33 71.05,55.33 67.53,51.81 67.53,51.41 66.7,50.59 66.05,49.94 64.92,49.94 64.25,49.27 64.25,47.69 61.9,45.34 60.88,45.34 60.48,44.93 60.48,44.24 59.33,43.1 59.33,42.37 50.93,33.97 49.99,33.97
  BOTTOM w0.089: U1.AU54 41.5,34.59 41.81,34.59 v1(42,34.4)
  BOTTOM w0.102: v2(71.8,55.15) 71.33,55.15 v1(71.12,55.36)
M_CHA_DQ46: length 43.6
  TOP w0.089: v1(44.25,36.92) 43.71,37.46 v2(43.69,37.46)
  TOP w0.102: v1(70.89,58.79) 71.33,58.35 U4.A7
  IN3 w0.089: v1(44.25,36.92) 44.85,36.32 46.46,36.32
  IN3 w0.102: 70.8,58.75 70.86,58.75 v1(70.89,58.79)
  IN3 w0.178: 46.46,36.32 48.44,36.32 48.74,36.62 49.34,36.62 56.19,43.46 56.19,44.21 59.67,47.7 59.67,49.66 61.17,51.16 61.17,52.14 61.39,52.37 62.65,52.37 64.25,53.97 64.9,53.97 67.81,56.88 67.81,57.71 68.85,58.75 70.8,58.75
  BOTTOM w0.089: v1(44.25,36.92) 43.94,36.61 43.04,36.61 42.85,36.52 42.64,36.43 42.43,36.43 42.05,36.25 41.87,36.16 U1.AV52
M_CHA_DQ47: length 47.5
  TOP w0.102: 71.87,60.55 72.32,60.1 72.32,59.61 U4.B8
  TOP w0.191: v2(69.06,60.7) 69.45,60.7 69.55,60.8 v1(69.83,60.8) 69.83,60.8 69.83,60.52 70.16,60.19 70.7,60.19 70.8,60.29 70.8,60.43 70.92,60.55 71.87,60.55
  IN3 w0.089: 46.31,37.85 46.23,37.92 45.59,37.92 v1(45.2,37.53)
  IN3 w0.178: v1(69.83,60.8) 69.56,60.53 68.92,60.53 66.7,58.31 66.7,57.41 66.2,56.9 64.39,56.9 62.11,54.62 62.11,54.55 61.04,53.47 60.84,53.47 60.07,52.7 60.07,51.61 58.57,50.12 58.57,48.16 55.08,44.67 55.08,44.02 48.92,37.85 46.31,37.85
  BOTTOM w0.089: U1.AU52 41.54,36.5 42.15,36.5 42.33,36.59 42.47,36.73 42.47,36.97 42.75,37.11 42.88,37.11 43.02,37.04 43.44,37.04 43.77,37.37 43.77,37.41 44.28,37.92 44.93,37.92 45.2,37.65 v1(45.2,37.53)
M_CHA_DQ48: length 55.7
  TOP w0.102: 71.6,71.34 71.86,71.09 72.38,71.09 U5.B8
  TOP w0.191: v1(71.4,71.47) 71.43,71.47 71.48,71.42 71.53,71.42 71.6,71.34
  IN3 w0.089: 45.57,46.22 44.66,45.31 40.29,45.31 39.8,44.82 39.8,44.56 39.43,44.19 38.43,44.19 37.96,43.71 37.54,43.71 v1(37.11,43.27)
  IN3 w0.178: 45.57,46.22 45.57,49.6 49.33,53.36 49.33,59.86 51.62,62.15 53.72,62.15 55.04,63.47 55.04,63.94 56.94,65.83 57.71,65.83 60.54,68.66 62.78,68.66 64.29,70.18 66.91,70.18 68.73,72 70.87,72 v1(71.4,71.47)
  BOTTOM w0.089: v1(37.11,43.27) 37.11,43.37 U1.AK40
  BOTTOM w0.191: v1(71.4,71.47) v2(71.4,72.23)
M_CHA_DQ49: length 57.9
  TOP w0.102: U5.C8 v1(73.18,71.09)
  IN3 w0.089: v1(36.37,43.32) 36.09,43.6 36.09,44.93 36.5,45.34 38.6,45.34 38.96,45.7 38.96,46.49 39.6,47.13 40.38,47.13 46.47,53.22
  IN3 w0.178: v1(73.18,71.09) 73.18,72.31 72.73,72.75 68.15,72.75 67.32,71.92 66.12,71.92 65.11,70.91 63.99,70.91 62.48,69.41 60.25,69.41 57.4,66.57 56.63,66.57 53.8,63.73 52.16,63.73 48.53,60.1 48.53,53.81 47.94,53.22 46.47,53.22
  BOTTOM w0.089: U1.AK42 36.46,43.18 36.46,43.23 v1(36.37,43.32)
  BOTTOM w0.191: v1(73.18,71.09) 73.48,71.39 v2(73.48,71.75)
M_CHA_DQ50: length 54.1
  TOP w0.089: v2(38.69,41.67) 37.95,41.67 v1(37.77,41.5)
  TOP w0.191: v1(70.77,67.25) 70.77,67.55 70.97,67.75 72.52,67.75 U5.C3
  IN3 w0.089: 46.31,44.5 45.15,43.35 41.42,43.35 40.75,42.68 40.75,42.2 40.49,41.94 39.49,41.94 39.04,41.5 v1(37.77,41.5)
  IN3 w0.178: v1(70.77,67.25) 70.66,67.15 67.11,67.15 66.63,66.67 65.74,66.67 64.97,65.9 60.44,65.9 56.22,61.69 55.58,61.69 54.35,60.46 53.72,60.46 50.92,57.65 50.92,52.58 48.34,50.01 48.34,46.52 46.32,44.5 46.31,44.5
  BOTTOM w0.089: U1.AM43 38.08,41.81 v1(37.77,41.5)
M_CHA_DQ51: length 51.7
  TOP w0.191: v1(70.33,66.29) 70.73,65.89 U5.A2
  IN3 w0.089: v1(38.41,40.51) 38.81,40.11 39.25,40.11 39.8,40.66 40.56,40.66 41.11,41.2 41.11,41.52 41.61,42.02 44.97,42.02 46.34,43.39
  IN3 w0.178: 46.34,43.39 47.54,43.39 49.51,45.36 49.51,49.61 52.08,52.19 52.08,54.42 52.62,54.96 52.62,55.29 56.47,59.14 57.15,59.14 58.42,60.41 58.42,62.14 60.51,64.23 62.31,64.23 62.88,64.8 66.64,64.8 67.85,66.02 68.01,66.02 68.28,65.75 68.53,65.75 68.79,66.02 69.31,66.02 69.47,65.85 69.9,65.85 v1(70.33,66.29)
  BOTTOM w0.089: v1(38.41,40.51) 38.41,40.52 38.08,40.85 U1.AM45
  BOTTOM w0.191: v1(70.33,66.29) v2(71.17,66.29)
M_CHA_DQ52: length 52.8
  TOP w0.089: v2(36.45,41.31) 36.93,41.31 v1(37.11,41.5)
  TOP w0.191: U5.A3 71.98,66.8 v1(71.5,67.28)
  IN3 w0.089: v1(37.11,41.5) 37.51,41.1 39.31,41.1 39.38,41.03 40.43,41.03 40.75,41.35 40.75,41.76 40.92,41.93 40.92,42.6 41.49,43.17 45.29,43.17 46.04,43.92
  IN3 w0.178: 46.04,43.92 46.27,43.92 48.77,46.42 48.77,49.92 51.28,52.43 51.28,55.48 55.72,59.91 56.11,59.91 56.57,60.37 56.57,61.51 60.59,65.54 65.22,65.54 65.91,66.24 67.01,66.24 67.55,66.78 71.01,66.78 v1(71.5,67.28)
  BOTTOM w0.089: U1.AK45 37.11,41.26 v1(37.11,41.5)
M_CHA_DQ53: length 54.9
  TOP w0.191: v1(69.7,66.31) 69.7,66.55 70.11,66.96 70.38,66.96 70.6,66.75 71.17,66.75 71.64,66.27 73.19,66.27 U5.C2
  IN3 w0.089: 46.09,43.65 44.66,42.23 41.57,42.23 40.93,41.59 40.93,41.28 40.5,40.85 39.3,40.85 39.24,40.92 37.12,40.92 36.54,41.5 v1(36.54,42.4)
  IN3 w0.178: 46.09,43.65 46.46,43.65 49.14,46.33 49.14,49.76 51.72,52.34 51.72,54.58 52.25,55.11 52.25,55.44 56.31,59.5 56.62,59.5 57.51,60.39 57.51,61.93 60.75,65.17 66.47,65.17 67.72,66.41 69.6,66.41 v1(69.7,66.31)
  BOTTOM w0.089: U1.AK43 36.78,42.16 v1(36.54,42.4)
M_CHA_DQ54: length 54.1
  TOP w0.102: U5.A7 71.71,69.89 v1(71.43,70.17)
  IN3 w0.089: v1(37.75,44.11) 37.78,44.11 38.31,44.64 38.31,44.82 38.56,45.07 38.58,45.07 39.14,45.62 39.14,45.77 39.48,46.11 40.46,46.11 41.09,46.74 41.09,47.54 42.9,49.35 44.27,49.35
  IN3 w0.178: v1(71.43,70.17) 72.01,70.76 72.01,71.5 71.13,72.38 68.3,72.38 66.47,70.55 64.14,70.55 62.62,69.03 60.39,69.03 57.56,66.2 56.78,66.2 53.95,63.36 52.32,63.36 48.79,59.84 48.79,53.7 44.45,49.35 44.27,49.35
  BOTTOM w0.089: v1(37.75,44.11) 38.08,43.78 U1.AM40
  BOTTOM w0.102: v2(71.93,69.66) v1(71.43,70.17)
M_CHA_DQ55: length 56.6
  TOP w0.089: v2(37.03,44.01) 37.03,43.98 v1(37.75,43.27)
  TOP w0.102: U5.D7 73.98,70.29 v1(72.38,70.29)
  IN3 w0.089: v1(37.75,43.27) 38.01,43.53 38.03,43.53 38.51,44.01 39.5,44.01 39.97,44.48 39.97,44.75 40.32,45.1 44.92,45.1 45.85,46.03
  IN3 w0.178: 45.85,46.03 45.85,49.36 49.6,53.1 49.6,59.43 51.95,61.78 53.88,61.78 55.34,63.24 56,63.24 60.33,67.57 60.33,67.93 60.69,68.29 63.27,68.29 63.63,67.94 64.15,67.94 64.85,68.64 64.85,68.81 65.19,69.16 66.6,69.16 67.29,69.84 69.17,69.84 69.85,69.16 70.87,69.16 71.2,69.49 71.57,69.49 v1(72.38,70.29)
  BOTTOM w0.089: v1(37.75,43.27) 38.08,42.94 U1.AM42
M_CHA_DQ56: length 60.6
  TOP w0.089: v1(37.75,39.45) 37.77,39.47 v2(37.77,40.15)
  TOP w0.102: U5.H8 77.18,70.29 v1(77.18,70.29)
  IN3 w0.089: v1(37.75,39.45) 38.09,39.79 38.55,39.79 38.58,39.76 39.45,39.76 39.63,39.93 40.11,39.93 40.37,39.68 40.79,39.68 41.41,40.3 42.97,40.3 43.43,40.76 44.54,40.76 45.88,42.11
  IN3 w0.178: v1(77.18,70.29) 76.71,69.82 74.65,69.82 72.95,68.11 72.95,66.9 72.42,66.36 71.63,66.36 69.95,64.68 67.74,64.68 67.01,63.95 63.24,63.95 62.66,63.38 60.86,63.38 60.43,62.94 60.43,62.05 59.86,61.49 59.86,60.64 58.57,59.35 58.57,58.15 54.99,54.58 54.05,54.58 52.94,53.46 52.94,51.84 50.47,49.37 50.47,44.61 47.97,42.11 45.88,42.11
  BOTTOM w0.089: v1(37.75,39.45) 37.75,39.67 U1.AM46
M_CHA_DQ57: length 59.3
  TOP w0.102: U5.F8 75.58,70.29 v1(75.58,70.29)
  IN3 w0.089: 46.59,43.12 45.26,41.8 43.64,41.8 43.23,41.39 43.23,40.9 42.81,40.48 39.87,40.48 39.33,39.93 38.66,39.93 38.63,39.97 36.92,39.97 v1(36.5,39.54)
  IN3 w0.178: 46.59,43.12 47.91,43.12 50.01,45.23 50.01,49.44 52.57,51.99 52.57,53.61 54.46,55.51 54.46,55.77 59.49,60.8 59.49,62.53 60.71,63.75 62.51,63.75 63.08,64.32 66.84,64.32 67.58,65.05 69.79,65.05 71.55,66.82 72.36,66.82 72.65,67.11 72.65,68.22 74.7,70.27 75.56,70.27 v1(75.58,70.29)
  BOTTOM w0.089: v1(36.5,39.54) 36.78,39.83 U1.AK46
  BOTTOM w0.102: v2(75.58,71.01) v1(75.58,70.29)
M_CHA_DQ58: length 56.7
  TOP w0.102: U5.E3 74.78,66.28 v1(74.78,66.29)
  IN3 w0.089: v1(37.75,37.65) 37.88,37.52 38.45,37.52 38.84,37.13 39.39,37.13 39.47,37.22 40.01,37.22 40.1,37.13 42.62,37.13 44.05,38.56 45.19,38.56 46.07,39.44
  IN3 w0.178: v1(74.78,66.29) 74.25,65.76 74.25,63.59 73.99,63.34 72.14,63.34 71.83,63.03 71.83,62.7 71.52,62.4 70.67,62.4 70.33,62.73 68.61,62.73 66.41,60.54 64.86,60.54 62.73,58.4 61.59,58.4 60.42,57.24 60.42,56.5 58.4,54.47 58.4,53.78 53.49,48.87 53.49,44.67 48.56,39.74 46.81,39.74 46.51,39.44 46.07,39.44
  BOTTOM w0.089: U1.AM49 37.92,37.89 37.92,37.81 v1(37.75,37.65)
  BOTTOM w0.102: v1(74.78,66.29) 74.6,66.11 v2(74.6,65.19)
M_CHA_DQ59: length 58.7
  TOP w0.102: U5.F2 v1(75.58,66.29)
  IN3 w0.089: 46.31,39.07 45.95,39.07 45.26,38.38 44.12,38.38 42.7,36.95 39.99,36.95 39.92,37.02 39.54,37.02 39.48,36.95 38.77,36.95 38.5,37.22 37.54,37.22 v1(37.1,37.66)
  IN3 w0.178: 46.31,39.07 46.69,39.07 47,39.39 48.73,39.39 53.86,44.52 53.86,46.16 56.82,49.12 56.82,50.09 58.85,52.12 58.85,54.21 61.15,56.51 62.28,56.51 63.13,57.37 63.13,58.27 65.03,60.17 66.58,60.17 68.76,62.35 70.11,62.35 70.43,62.03 72.47,62.03 72.59,62.15 72.59,62.7 72.72,62.83 74.5,62.83 74.7,63.03 74.7,65.41 v1(75.58,66.29)
  BOTTOM w0.089: U1.AK49 37.1,37.75 v1(37.1,37.66)
  BOTTOM w0.102: v2(74.5,66.97) 74.9,66.97 v1(75.58,66.29)
M_CHA_DQ60: length 59.2
  TOP w0.102: U5.H7 77.17,69.47 v1(77.17,69.44)
  IN3 w0.089: 46.7,41.27 45.57,41.27 44.88,40.57 44.87,40.57 44.64,40.34 44.64,40.34 44.58,40.28 44.58,40.26 44.57,40.25 44.57,40.01 44.33,39.77 44,39.77 43.92,39.85 43.51,39.85 43.23,39.57 43.23,39.34 42.99,39.09 40.2,39.09 40.06,38.96 38.87,38.96 v1(38.44,38.53)
  IN3 w0.178: 46.7,41.27 48.17,41.27 51.21,44.3 51.21,49.07 55.51,53.37 55.51,54.06 59.3,57.85 59.3,59.04 60.6,60.34 60.6,61.18 60.87,61.45 62.04,61.45 63.27,62.68 63.27,62.94 63.54,63.21 67.34,63.21 68.07,63.95 70.28,63.95 71.81,65.47 72.44,65.47 73.53,66.57 73.53,67.84 74.22,68.52 76.25,68.52 v1(77.17,69.44)
  BOTTOM w0.089: U1.AM48 38.08,38.89 v1(38.44,38.53)
  BOTTOM w0.102: v1(77.17,69.44) 77.38,69.65 77.54,69.65 v2(77.83,69.94)
M_CHA_DQ61: length 58.9
  TOP w0.102: v1(75.06,69.34) 75.43,69.34 U5.F7
  IN3 w0.089: 45.79,41.7 45.73,41.7 44.61,40.58 43.5,40.58 43.04,40.12 41.56,40.12 40.84,39.41 40.26,39.41 39.99,39.13 38.67,39.13 38.52,38.99 36.97,38.99 v1(36.51,38.53)
  IN3 w0.178: v1(75.06,69.34) 74.64,69.34 73.23,67.93 73.23,66.78 72.3,65.85 71.65,65.85 70.12,64.32 67.91,64.32 67.17,63.58 63.39,63.58 62.9,63.1 62.9,62.83 61.89,61.82 60.71,61.82 60.23,61.34 60.23,60.49 58.94,59.2 58.94,58 55.14,54.21 55.14,53.52 50.84,49.22 50.84,44.46 48.08,41.7 45.79,41.7
  BOTTOM w0.089: U1.AK48 36.78,38.81 36.51,38.54 v1(36.51,38.53)
  BOTTOM w0.102: v2(74.35,69.34) v1(75.06,69.34)
M_CHA_DQ62: length 58.5
  TOP w0.089: v1(38.41,36.62) 39.17,35.86 v2(39.17,35.83)
  TOP w0.102: v1(76.38,66.29) 77.18,66.29 U5.H3
  IN3 w0.089: 46.31,38.7 45.84,38.7 45.34,38.2 44.2,38.2 42.11,36.11 39.55,36.11 39.04,36.62 38.41,36.62 v1(38.41,36.62)
  IN3 w0.178: 46.31,38.7 46.71,38.7 46.92,38.5 48.36,38.5 54.23,44.37 54.23,45.98 57.24,48.99 57.24,49.99 59.21,51.97 59.21,53.55 60.61,54.94 61.23,54.94 63.5,57.21 63.5,58.05 65.25,59.8 66.74,59.8 68.89,61.94 69.75,61.94 70.03,61.66 73.84,61.66 75.01,62.83 75.01,64.57 75.47,65.03 75.77,65.03 76.38,65.64 v1(76.38,66.29)
  BOTTOM w0.089: U1.AM51 38.41,36.72 v1(38.41,36.62)
M_CHA_DQ63: length 58.1
  TOP w0.102: v1(75.64,63.92) 76.15,64.43 76.15,64.77 76.38,65 76.38,65.48 U5.G2
  IN3 w0.089: v1(37.11,36.65) 37.57,36.18 39.17,36.18 39.42,35.93 42.18,35.93 44.27,38.02 45.41,38.02 45.72,38.33 46.31,38.33
  IN3 w0.178: v1(75.64,63.92) 75.64,62.55 74.38,61.29 69.54,61.29 69.27,61.02 68.72,61.02 67.14,59.43 65.44,59.43 63.87,57.86 63.87,57.06 61.38,54.58 60.76,54.58 59.58,53.4 59.58,51.81 57.61,49.84 57.61,48.84 54.6,45.83 54.6,44.22 48.55,38.17 46.47,38.17 46.31,38.33
  BOTTOM w0.089: U1.AK51 36.78,36.98 v1(37.11,36.65)
  BOTTOM w0.102: v1(75.64,63.92) 76.05,63.52 v2(76.05,63.29)
M_CHA_DQS0: length 52.7
  TOP w0.229: v1(75.62,25.21) 75.39,25.21 75.24,25.06 75.24,24.81 75.39,24.66 76.29,24.66 76.44,24.5 76.44,24.05 76.21,23.81 U2.F3
  IN3 w0.229: v1(36.02,25.9) 35.75,25.63 35.75,25.51 36.23,25.02 37.4,25.02 37.64,25.26 46.29,25.26 47.43,24.12 47.45,24.12 49.67,21.9 59.27,21.9 60.6,23.23 67.56,23.23 70.4,26.08 71.39,26.08 71.82,25.65 73.9,25.65 74.26,25.29 74.71,25.29 75.2,24.81 75.48,24.81 75.62,24.95 v1(75.62,25.21)
  BOTTOM w0.089: U1.AJ62 36.31,30.15 36.26,30.1 36.26,29.72 36.17,29.55 36.17,29.55 36.17,29.46 36.26,29.28 36.26,28.69 36.16,28.6 36.16,27.26 35.62,26.72 35.62,26.15 35.87,25.9 v1(36.02,25.9)
M_CHA_DQS0#: length 52.8
  TOP w0.229: U2.G3 76.77,23.82 76.77,24.82 v1(76.38,25.21)
  IN3 w0.229: v1(76.38,25.21) 76.35,25.21 75.62,24.48 75.06,24.48 74.58,24.96 74.12,24.96 73.76,25.32 71.68,25.32 71.25,25.75 70.54,25.75 67.69,22.9 60.73,22.9 59.4,21.57 49.53,21.57 46.16,24.95 37.78,24.95 37.53,24.71 36.1,24.71 35.43,25.37 35.43,25.74 v1(35.27,25.9)
  BOTTOM w0.089: U1.AJ61 36.08,30.17 36.08,29.76 36.01,29.63 35.99,29.59 35.99,29.42 36.08,29.24 36.08,28.77 35.98,28.67 35.98,27.33 35.44,26.79 35.44,26.06 35.28,25.9 v1(35.27,25.9)
M_CHA_DQS1: length 43.9
  TOP w0.229: v1(73.53,24.83) 73.51,24.86 73.51,26.94 U2.C7
  IN1 w0.089: 49.81,25.8 49.77,25.8 49.66,25.7 49.3,25.7 48.79,26.2 41.87,26.2 41.51,26.57 41.51,26.79 41.28,27.02 40.88,27.02 40.77,27.13 v1(40.42,27.13)
  IN1 w0.267: 49.81,25.8 52.49,25.8 54.06,24.23 58.21,24.23 59.17,23.27 68.01,23.27 69.25,24.51 69.25,25.31 70.06,26.12 71.41,26.12 71.89,25.63 72.94,25.63 73.53,25.04 v1(73.53,24.83)
  BOTTOM w0.089: v1(40.42,27.13) 40.09,27.13 40.01,27.21 40.01,27.59 39.55,28.05 39.55,28.67 39.29,28.93 39.29,29.24 39.36,29.4 39.36,29.61 39.29,29.77 39.29,30.23 U1.AN61
M_CHA_DQS1#: length 44.1
  TOP w0.229: U2.B7 73.06,27.01 73.18,26.89 73.18,25.16 72.77,24.75 v1(72.77,24.72)
  IN1 w0.089: 49.81,25.41 49.77,25.41 49.66,25.52 49.23,25.52 48.72,26.03 41.8,26.03 41.33,26.5 41.33,26.72 41.2,26.84 40.97,26.84 40.9,26.76 v4(40.9,26.48)
  IN1 w0.267: v1(72.77,24.72) 72.93,24.88 72.93,25.08 72.77,25.24 71.73,25.24 71.25,25.72 70.22,25.72 69.65,25.15 69.65,24.35 68.17,22.87 59.01,22.87 58.04,23.84 53.9,23.84 52.33,25.41 49.81,25.41
  BOTTOM w0.089: U1.AN62 39.05,30.15 39.11,30.09 39.11,29.72 39.18,29.57 39.18,29.44 39.11,29.28 39.11,28.86 39.37,28.6 39.37,27.98 39.84,27.52 39.84,27.13 40.48,26.48 v4(40.9,26.48)
M_CHA_DQS2: length 46.1
  TOP w0.102: U3.F3 75.92,35.28 75.92,35.07 76.05,34.94 v1(76.38,34.94)
  IN1 w0.089: v1(38.99,31.95) 38.99,32.2 39.04,32.25 39.98,32.25 40.2,32.47 40.74,32.47 40.82,32.39 42.38,32.39 43.26,31.51 47.65,31.51 47.65,31.51 49.66,31.51 49.77,31.4 49.81,31.4
  IN1 w0.267: 49.81,31.4 53.23,31.4 55,29.63 59.09,29.63 59.7,29.02 66.33,29.02 66.68,29.37 67.04,29.73 67.04,30.38 66.71,30.71 66.71,30.96 67.05,31.29 67.34,31.29 67.62,31.01 68.12,31.01 68.61,31.49 68.61,32.3 69.15,32.85 70.28,33.98 74.28,33.98 75.25,34.94 75.41,34.94 v1(76.38,34.94)
  BOTTOM w0.089: v1(38.99,31.95) 39.13,32.09 39.13,32.24 38.97,32.4 U1.AN58
  BOTTOM w0.102: v1(76.38,34.94) 75.59,34.94 v2(75.44,34.79)
M_CHA_DQS2#: length 46.7
  TOP w0.102: v1(76.32,35.79) 76.33,35.79 U3.G3
  IN1 w0.089: v1(38.37,31.94) 38.85,32.43 39.91,32.43 40.13,32.65 40.81,32.65 40.89,32.56 42.46,32.56 43.33,31.69 47.72,31.69 47.73,31.68 49.66,31.68 49.77,31.79 49.81,31.79
  IN1 w0.267: 49.81,31.79 53.39,31.79 55.17,30.02 59.25,30.02 59.86,29.41 66.17,29.41 66.4,29.65 66.65,29.9 66.65,30.22 66.32,30.55 66.32,31.12 66.88,31.68 67.5,31.68 67.78,31.4 67.96,31.4 68.21,31.65 68.21,32.47 68.87,33.13 70.12,34.37 74.12,34.37 75.08,35.34 75.57,35.34 75.86,35.34 v1(76.32,35.79)
  BOTTOM w0.089: v1(38.37,31.94) 38.21,32.1 38.21,32.26 U1.AM58
  BOTTOM w0.102: v1(76.32,35.79) 76.94,35.17 v2(77.29,35.17)
M_CHA_DQS3: length 48.1
  TOP w0.229: U3.C7 73.58,36.71 v1(73.45,36.58)
  IN3 w0.089: v1(38.45,33.8) 38.15,33.5 38.15,33.39 37.97,33.22 37.59,33.22 37.26,32.88 37.26,31.84 38.61,30.5 40.49,30.5
  IN3 w0.229: v1(73.45,36.58) 73.33,36.69 73.33,37.08 73,37.41 71.59,37.41 70.32,36.14 69.14,36.14 68.41,35.41 68.41,34.84 66.19,32.62 65.7,32.62 63.48,30.4 61.48,30.4 58.76,27.68 53.57,27.68 53.23,28.02 51.5,28.02 51.34,28.17 50.83,28.17 50.81,28.16 48.9,28.16 48.48,28.58 44.24,28.58 42.32,30.5 40.49,30.5
  BOTTOM w0.089: v1(38.45,33.8) 38.46,33.81 38.46,33.97 U1.AN55
M_CHA_DQS3#: length 48.4
  TOP w0.229: U3.B7 73.01,38.54 73.25,38.31 73.25,37.06 72.97,36.78 72.97,36.74 v1(72.81,36.58)
  IN3 w0.089: v1(37.81,33.81) 37.97,33.65 37.97,33.47 37.9,33.39 37.52,33.39 37.09,32.96 37.09,31.77 38.54,30.32 40.31,30.32 40.45,30.18 40.49,30.18
  IN3 w0.229: v1(72.81,36.58) 72.81,36.59 73,36.78 73,36.94 72.86,37.08 71.73,37.08 70.46,35.81 69.28,35.81 68.74,35.27 68.74,34.7 66.33,32.29 65.84,32.29 63.62,30.07 61.62,30.07 58.9,27.35 53.43,27.35 53.09,27.69 51.36,27.69 51.21,27.84 48.77,27.84 48.35,28.26 44.1,28.26 42.19,30.18 40.49,30.18
  BOTTOM w0.089: U1.AM55 37.94,34.24 37.81,34.12 v1(37.81,33.81)
M_CHA_DQS4: length 49.2
  TOP w0.229: U4.F3 76.3,55.47 76.3,55.73 76.09,55.95 75.69,55.95 75.59,56.05 v1(75.59,56.43)
  IN3 w0.089: 50.83,31.98 50.81,31.98 50.65,31.83 50.23,31.83 50.19,31.79 45.74,31.79 45.67,31.87 v1(45.67,32.17)
  IN3 w0.229: v1(75.59,56.43) 75.95,56.08 75.95,55.7 75.81,55.57 75.15,55.57 74.47,54.89 74.47,52.93 72.44,50.9 72.44,50.05 70.88,48.48 70.88,48.27 66.83,44.22 66.42,43.82 64.73,43.82 61.35,40.44 60.21,40.44 51.75,31.98 50.83,31.98
  BOTTOM w0.089: v1(45.67,32.17) 45.67,32.53 45.57,32.62 43.85,32.62 43.64,32.83 43.03,32.83 42.88,32.76 42.75,32.76 42.43,32.9 42.38,32.93 42.24,33 U1.AW57
M_CHA_DQS4#: length 49.4
  TOP w0.229: U4.G3 76.63,55.3 76.63,55.87 76.28,56.23 v1(76.28,56.46)
  IN3 w0.089: v1(45.03,32.17) 45.59,31.61 50.27,31.61 50.31,31.65 50.83,31.65
  IN3 w0.229: 50.83,31.65 51.89,31.65 60.35,40.11 61.49,40.11 64.87,43.49 66.56,43.49 71.21,48.13 71.21,48.35 72.77,49.91 72.77,50.76 74.8,52.79 74.8,54.75 75.29,55.24 75.95,55.24 76.28,55.57 v1(76.28,56.46)
  BOTTOM w0.089: v1(45.03,32.17) 44.77,32.44 43.79,32.44 43.57,32.65 43.08,32.65 42.92,32.58 42.72,32.58 42.5,32.68 42.42,32.71 42.1,32.75 U1.AV57
M_CHA_DQS5: length 45.4
  TOP w0.229: v1(69.29,58.13) 69.47,57.95 69.47,57.82 70.14,57.15 72.82,57.15 73.51,57.84 73.51,58.28 U4.C7
  IN3 w0.089: v1(45.02,35.51) 45.02,35.7 45.33,36.01 46.04,36.01 46.58,35.47 49.17,35.47 50.58,36.88 50.58,37.02 50.59,37.03
  IN3 w0.229: v1(69.29,58.13) 69.02,57.86 68.76,57.86 68.2,57.3 68.2,56.49 66.93,55.22 66.93,55.01 62.38,50.46 61.37,50.46 60.07,49.16 60.07,47.52 58.56,46.01 58.56,45 57.78,44.21 57.78,44.19 57.47,43.88 57.45,43.88 50.59,37.03
  BOTTOM w0.089: v1(45.02,35.51) 45.02,35.74 44.86,35.9 44.12,35.9 43.91,35.69 43.04,35.69 42.88,35.76 42.75,35.76 42.6,35.69 42.33,35.69 U1.AW53
M_CHA_DQS5#: length 45.6
  TOP w0.229: v1(69.95,58.13) 69.95,57.8 70.27,57.48 72.68,57.48 73.18,57.98 73.18,58.21 73.03,58.35 U4.B7
  IN3 w0.089: v1(45.64,35.51) 45.64,35.71 45.75,35.82 45.99,35.82 46.51,35.3 49.24,35.3 50.69,36.75 50.8,36.75 50.83,36.77 50.83,36.8
  IN3 w0.229: v1(69.95,58.13) 69.78,57.95 69.78,57.93 69.38,57.53 68.9,57.53 68.53,57.17 68.53,56.35 67.26,55.08 67.26,54.87 62.52,50.13 61.5,50.13 60.4,49.02 60.4,47.38 58.89,45.88 58.89,44.86 58.11,44.08 58.11,44.05 57.61,43.55 57.58,43.55 50.83,36.8
  BOTTOM w0.089: v1(45.64,35.51) 45.07,36.08 44.05,36.08 43.83,35.86 43.08,35.86 42.92,35.94 42.71,35.94 42.56,35.86 41.98,35.86 U1.AV53
M_CHA_DQS6: length 54.1
  TOP w0.102: v1(72.06,68.93) 72.06,69.18 72.42,69.54 73.23,69.54 U5.C7
  IN3 w0.089: 46.28,45.28 46.21,45.28 45.67,44.74 44.17,44.74 43.03,43.6 41.35,43.6 40.83,43.08 40.32,43.08 39.94,42.7 38.02,42.7 v1(37.76,42.44)
  IN3 w0.229: 46.28,45.28 46.98,45.98 46.98,49.06 50.43,52.51 50.43,59.06 52.22,60.85 54.19,60.85 55.51,62.17 55.96,62.17 59.16,65.37 60.68,66.9 64.73,66.9 65.95,68.11 66.4,68.11 66.75,67.76 71.39,67.76 71.86,68.23 71.86,68.73 v1(72.06,68.93)
  BOTTOM w0.089: U1.AL42 37.57,42.72 37.57,42.62 v1(37.76,42.44)
M_CHA_DQS6#: length 54.4
  TOP w0.102: U5.B7 72.64,69.74 72.34,69.74 72.13,69.54 71.71,69.54 71.38,69.21 v1(71.38,68.98)
  IN3 w0.089: 46.06,45.5 46.03,45.48 46.03,45.36 45.59,44.92 44.1,44.92 42.96,43.78 41.28,43.78 40.75,43.25 40.25,43.25 39.87,42.88 37.95,42.88 37.9,42.84 37.55,42.84 v1(37.15,42.44)
  IN3 w0.229: v1(71.38,68.98) 71.53,68.83 71.53,68.37 71.25,68.09 66.89,68.09 66.53,68.44 65.81,68.44 64.59,67.23 60.54,67.23 59.16,65.84 55.82,62.5 55.37,62.5 54.05,61.18 52.09,61.18 50.6,59.7 50.6,59.68 50.12,59.19 50.12,52.65 46.66,49.19 46.66,46.11 46.06,45.5
  BOTTOM w0.089: U1.AL43 37.15,42.19 v1(37.15,42.44)
M_CHA_DQS7: length 56.5
  TOP w0.229: v1(75.54,67.15) 75.54,67.13 U5.F3
  IN3 w0.089: v1(37.13,38.53) 37.16,38.5 37.16,38.5 37.53,38.13 37.93,38.13 38.11,37.95 40.63,37.95 41.42,38.73 45.11,38.73 45.49,39.11 45.49,39.43 45.94,39.88 46.04,39.88 46.05,39.88 46.07,39.9
  IN3 w0.229: 46.07,39.9 46.49,40.31 48.58,40.31 52.27,44.01 52.27,48.65 57.35,53.73 57.35,54.19 58.04,54.88 58.25,54.88 60.03,56.66 60.03,58.6 60.78,59.34 62.41,59.34 64.54,61.48 66.74,61.48 68.4,63.14 70.57,63.14 72.17,64.74 72.6,64.74 74.19,66.33 74.19,66.48 75.04,67.33 75.37,67.33 v1(75.54,67.15)
  BOTTOM w0.089: U1.AL49 37.43,38.23 v1(37.13,38.53)
M_CHA_DQS7#: length 56.9
  TOP w0.229: U5.G3 76.78,66.88 v1(76.28,67.38)
  IN3 w0.089: 45.85,40.12 45.82,40.1 45.82,40.01 45.32,39.5 45.32,39.19 45.04,38.91 41.34,38.91 40.56,38.13 38.18,38.13 v1(37.78,38.53)
  IN3 w0.229: v1(76.28,67.38) 76,67.66 74.91,67.66 73.86,66.62 73.86,66.46 72.47,65.07 72.04,65.07 70.44,63.47 68.26,63.47 66.6,61.81 64.41,61.81 62.27,59.67 60.64,59.67 59.7,58.73 59.7,56.8 58.11,55.21 57.91,55.21 57.02,54.33 57.02,53.87 51.94,48.79 51.94,44.15 50.59,42.8 50.59,42.78 48.44,40.63 46.36,40.63 45.85,40.12
  BOTTOM w0.089: U1.AL48 37.57,38.81 37.57,38.74 v1(37.78,38.53)
M_CHA_MAA0: length 132.1
  TOP w0.102: U3.N3 81.74,35.34 81.84,35.44 81.84,35.89 81.74,35.98 81.36,35.98 v1(81.18,35.81) ; v1(82.26,56.53) 81.59,55.85 81.59,55.16 U4.N3 ; U5.N3 81.71,66.82 81.71,66.96 81.54,67.13 v1(81.23,67.13) ; v1(82.68,24.84) 82.18,24.35 82.12,24.35 U2.N3
  TOP w0.267: v1(74.84,48.23) 75.15,47.91 R9.1
  IN1 w0.102: v1(81.18,35.81) 80.98,35.81 80.79,35.61 80.79,35.43 80.86,35.36 81.54,35.36 81.64,35.46 81.64,36.11 81.74,36.21 81.91,36.21 82.01,36.11 82.01,32.27 82.27,32.01 82.27,31.82 82.15,31.69 81.99,31.69 v1(81.68,32) 81.68,31.37 81.81,31.23 81.81,29.05 82.09,28.77 82.09,26.89 81.87,26.66 81.87,25.57 82.59,24.84 v1(82.68,24.84) ; v1(81.23,67.13) 81.83,67.13 82.03,66.93 82.03,66.3 81.93,66.2 81.66,66.2 81.56,66.1 81.56,65.89 81.66,65.79 81.93,65.79 82.03,65.69 82.03,65.4 81.93,65.3 81.7,65.3 81.6,65.19 81.6,65.02 81.7,64.91 82.07,64.91 82.16,64.82 82.16,63.4 82.27,63.29 82.88,63.29 82.98,63.19 82.98,63.01 82.88,62.91 82.35,62.91 82.25,62.81 82.25,62.54 v1(82.46,62.32) 82.46,61.98 82.76,61.68 82.76,59.6 81.73,58.57 81.73,56.11 81.84,56 82.15,56 82.26,56.12 v1(82.26,56.53)
  IN2 w0.089: 49.51,45.74 47.8,45.74 47.47,45.4 41.94,45.4 v1(41.54,45.8)
  IN2 w0.33: 49.51,45.74 52.53,45.74 53.85,44.42 54.83,44.42 55.06,44.2 55.06,43.21 56.16,42.11 56.88,42.11 57.2,42.44 57.2,44.77 57.49,45.06 59.8,45.06 60.37,45.63 61.57,45.63 61.93,45.28 63.17,45.28 63.88,45.99 63.88,46.42 63.63,46.68 63.22,46.68 62.69,46.15 62.33,46.15 61.95,46.53 61.95,47.21 62.23,47.49 62.94,47.49 63.27,47.82 63.27,48.35 63.93,49.01 64.55,49.01 64.8,48.77 71.87,48.77 72.6,49.5 73.56,49.5 v1(74.84,48.23)
  BOTTOM w0.089: U1.AU36 41.19,46.15 v1(41.54,45.8)
  BOTTOM w0.102: v1(81.68,32) 81.88,32.2 81.88,36.42 81.6,36.71 81.6,37.93 81.34,38.19 81.05,38.19 80.29,38.94 80.29,42.18 79.83,42.64 79.27,42.64 78.94,42.3 78.8,42.3 78.65,42.45 78.65,42.59 79.19,43.13 79.19,43.28 78.4,44.07 75.05,44.07 74.84,44.28 v1(74.84,48.23) 75.69,48.23 75.82,48.1 v2(75.82,47.67) 75.82,47.26 75.95,47.13 76.2,47.13 76.34,47.27 76.34,48.62 76.24,48.72 75.97,48.72 75.87,48.82 75.87,49.08 75.97,49.18 76.24,49.18 76.34,49.28 76.34,49.57 76.47,49.7 79.5,49.7 79.66,49.85 79.66,50.47 80.8,51.6 81.8,51.6 81.9,51.71 81.9,55.71 81.42,56.19 81.42,58.62 82.76,59.96 82.76,62.03 v1(82.46,62.32)
M_CHA_MAA1: length 132.6
  TOP w0.102: v1(84.69,57.21) 83.73,57.21 82.59,58.35 U4.P7 ; U2.P7 82.7,27.01 83.04,26.67 83.55,26.67 83.87,26.35 84.01,26.35 v1(84.54,25.82) ; v1(83.62,37.76) 83.62,36.97 83.52,36.87 83.16,36.87 83.06,36.97 83.06,37.76 82.96,37.86 82.48,37.86 82.38,37.96 U3.P7 ; U5.P7 83.72,68.55 v1(84.12,68.55)
  TOP w0.267: R10.1 87.83,50.46 v2(86.67,49.29) 86.18,48.81 v1(85.6,48.81)
  IN1 w0.102: v1(84.12,68.55) 84.8,67.87 84.8,64.71 85.01,64.5 85.95,63.57 85.95,61.43 v1(85.73,61.21) 85.73,60.57 86.01,60.29 86.23,60.29 86.39,60.14 86.39,59.58 86.08,59.28 85.6,59.28 85.42,59.1 85.42,58.59 85.19,58.35 84.14,58.35 84.03,58.24 84.03,57.28 84.1,57.21 v1(84.69,57.21) ; v1(84.54,25.82) 84.35,26 84.35,26.59 85.04,27.27 85.04,27.28 85.06,27.3 85.06,27.78 85.05,27.78 85.05,28.13 85.06,28.13 85.06,28.15 85.41,28.51 85.41,32.84 v1(85.21,33.04) 84.98,33.27 84.98,33.95 84.65,34.28 84.65,37.98 84.43,38.19 84.06,38.19 v1(83.62,37.76)
  IN2 w0.089: 49.51,46.26 47.81,46.26 47.39,45.83 v1(44.07,45.83)
  IN2 w0.33: v1(85.6,48.81) 83.73,50.68 83.18,50.68 82.81,50.31 82.81,48.42 82.08,47.69 81.61,47.69 81.43,47.87 81.43,48.2 81.23,48.4 80.7,48.4 80.51,48.21 80.51,47.88 80.32,47.69 79.5,47.69 79.3,47.9 79.3,48.48 79.07,48.71 78.21,48.71 77.71,48.21 75.69,48.21 73.88,50.02 72.39,50.02 71.76,49.39 66.95,49.39 66.47,49.88 63.53,49.88 63.22,49.57 63.22,49.04 62.99,48.8 61.06,48.8 60.69,48.44 60.69,46.7 59.58,45.58 57,45.58 56.68,45.27 56.68,43.42 56.41,43.15 55.92,43.15 55.58,43.49 55.58,44.6 55.23,44.94 54.06,44.94 52.75,46.26 49.51,46.26
  BOTTOM w0.089: U1.AY37 43.14,45.38 43.62,45.38 v1(44.07,45.83)
  BOTTOM w0.102: v1(85.21,33.04) 85.21,35.99 85.8,36.59 85.8,41.8 85.76,41.84 85.76,44.45 85.88,44.57 85.88,48.53 v1(85.6,48.81) 85.8,48.81 85.88,48.89 85.88,49.27 85.78,49.37 85.59,49.37 85.48,49.47 85.48,49.67 85.59,49.78 85.78,49.78 85.88,49.88 85.88,50.11 85.78,50.21 85.59,50.21 85.48,50.31 85.48,50.51 85.59,50.61 85.78,50.61 85.88,50.72 85.88,50.94 85.78,51.05 85.59,51.05 85.48,51.15 85.48,51.4 85.59,51.5 85.78,51.5 85.88,51.6 85.88,54.02 85.51,54.38 85.51,54.58 85.61,54.68 86.36,54.68 86.46,54.78 86.46,54.99 86.36,55.08 85.61,55.08 85.51,55.19 85.51,60.99 v1(85.73,61.21)
M_CHA_MAA2: length 137.3
  TOP w0.102: U2.P3 82.52,23.95 82.52,24.04 83.14,24.65 83.14,25.3 v1(82.9,25.54) ; U3.P3 82.38,36.83 82.55,37 82.73,37 82.89,36.84 v1(82.89,36.52) ; v1(82.96,56.63) 82.45,56.11 82.16,56.11 81.97,55.92 81.97,55.29 82.1,55.15 U4.P3 ; U5.P3 82.38,67.36 82.28,67.46 81.94,67.46 81.84,67.56 81.84,67.89 81.94,67.99 82.72,67.99 v1(82.89,67.82)
  TOP w0.267: v1(84.05,48.81) 84.89,48.81 87.58,51.5 R11.1
  IN1 w0.102: v1(82.9,25.54) 83.44,25.54 83.72,25.82 83.72,26.54 83.49,26.76 83.49,28.74 83.96,29.2 83.96,29.55 83.72,29.79 83.72,30.13 84.04,30.45 84.04,32.34 v1(83.95,32.43) 83.67,32.71 83.67,33.7 83.49,33.88 83,33.88 82.9,33.98 82.9,34.18 83,34.28 83.43,34.28 83.53,34.38 83.53,34.61 83.43,34.71 82.92,34.71 82.82,34.82 82.82,35.04 82.92,35.15 83.49,35.15 83.67,35.32 83.67,36.05 83.2,36.52 v1(82.89,36.52) ; v1(82.96,56.63) 82.96,56.33 83.06,56.23 83.26,56.23 83.59,56.56 83.59,59.53 84.24,60.18 84.24,61.6 v1(84.48,61.84) 84.7,62.06 84.7,62.79 84.28,63.21 84.28,63.92 83.71,64.5 83.71,67.29 83.18,67.82 v1(82.89,67.82)
  IN2 w0.089: 49.51,44.18 48.68,44.18 48.35,43.84 47.51,43.84 46.62,44.74 41.2,44.74 v1(40.23,45.71)
  IN2 w0.33: v1(84.05,48.81) 83.93,48.81 82.29,47.17 72.39,47.17 71.55,46.33 67.86,46.33 67.51,45.99 67.51,45.64 67.15,45.28 66.58,45.28 66.22,45.63 65.74,45.63 63.82,43.71 63.82,42.19 63.53,41.9 61.85,41.9 61.29,42.46 60.6,42.46 59.56,41.43 59.12,41.43 57.72,40.03 57.72,39.46 57.51,39.25 56.8,39.25 51.88,44.18 49.51,44.18
  BOTTOM w0.089: v1(40.23,45.71) 40.23,45.63 40.03,45.43 U1.AR38
  BOTTOM w0.102: v1(84.48,61.84) 84.1,61.84 84.02,61.76 84.02,61.54 84.24,61.33 84.24,60.18 83.58,59.52 83.58,58.81 83.68,58.71 83.82,58.71 83.93,58.6 83.93,58.4 83.82,58.3 83.68,58.3 83.58,58.2 83.58,57.99 83.68,57.89 83.82,57.89 83.93,57.79 83.93,57.59 83.82,57.49 83.68,57.49 83.58,57.38 83.58,57.18 83.68,57.08 83.82,57.08 83.93,56.98 83.93,56.77 83.82,56.67 83.68,56.67 83.58,56.57 83.58,56.27 83.31,56 83.01,56 82.91,55.9 82.91,54.12 83.01,54.02 83.8,54.02 83.91,53.92 83.91,52.32 84.27,51.96 84.27,50.92 84.16,50.82 83.9,50.82 83.8,50.72 83.8,50.33 83.9,50.23 84.16,50.23 84.27,50.13 84.27,49.73 84.16,49.62 82.81,49.62 82.7,49.52 82.7,48.91 82.81,48.81 v1(84.05,48.81) 84.05,48.15 83.85,47.95 82.81,47.95 82.7,47.85 v2(82.7,47.19) 82.7,46.55 82.81,46.45 83.52,46.45 83.62,46.35 83.62,45.99 83.52,45.89 83.24,45.89 83.14,45.79 83.14,45.46 83.24,45.36 83.52,45.36 83.62,45.26 83.62,44.03 83.81,43.84 83.81,41.53 84,41.34 84,37.97 84.04,37.93 84.04,37.55 83.72,37.23 83.72,35.41 83.53,35.22 83.53,32.85 v1(83.95,32.43)
M_CHA_MAA3: length 140
  TOP w0.102: U4.N2 81.58,53.99 81.48,53.89 81.29,53.89 81.19,53.99 v1(81.19,54.75) ; v1(81.2,36.44) 81.4,36.24 81.66,36.24 81.76,36.34 81.76,36.69 81.86,36.79 82.1,36.79 82.17,36.72 82.17,36.09 82.04,35.95 82.04,34.18 81.94,34.08 81.68,34.08 81.58,34.18 U3.N2 ; v1(81.19,22.61) 81.19,22.61 U2.N2 ; v1(81.17,67.79) 81.92,67.04 81.92,65.58 81.82,65.48 81.43,65.48 81.33,65.58 81.33,65.79 81.43,65.89 U5.N2
  TOP w0.267: R12.1 73.78,48.01 v1(74,48.23) 74.47,47.75 v2(74.47,47.59)
  IN1 w0.102: v1(81.17,67.79) 80.56,67.18 80.56,64.21 81.82,62.95 81.82,62.01 81.75,61.94 81.75,61.66 81.54,61.45 v1(81.54,60.98) 82.09,60.98 82.35,60.72 82.35,60.09 82.2,59.94 81.74,59.94 81.61,59.81 81.61,59.03 81.32,58.74 81.32,56.65 81.11,56.44 80.32,56.44 80.21,56.33 80.21,55.4 80.47,55.14 81.1,55.14 81.19,55.05 v1(81.19,54.75) ; v1(81.2,36.44) 80.85,36.8 80.67,36.8 80.59,36.71 80.59,36.3 80.76,36.12 80.76,35.87 80.59,35.7 80.59,34.93 80.82,34.69 80.82,34.46 80.59,34.22 80.59,33.68 80.65,33.62 81,33.62 81.08,33.7 81.3,33.7 81.4,33.6 81.4,33.42 81.13,33.14 v1(81.13,32.68) 81.03,32.58 81.03,31.69 80.71,31.38 80.71,29.49 81.69,28.52 81.69,27.22 81.4,26.93 81.4,25.74 80.57,24.91 80.57,23.82 81.19,23.2 v1(81.19,22.61)
  IN2 w0.089: 49.51,45.22 41.54,45.22 40.47,46.29 39.78,46.29 39.72,46.36 v1(39.72,46.68)
  IN2 w0.33: 49.51,45.22 52.31,45.22 53.63,43.9 54.21,43.9 54.53,43.58 54.53,42.99 55.94,41.59 57.81,41.59 58.07,41.85 58.07,42.44 58.29,42.66 58.76,42.66 58.99,42.89 58.99,43.34 58.75,43.58 57.99,43.58 57.72,43.85 57.72,44.25 58.02,44.54 60.28,44.54 60.68,44.14 62.77,44.14 64.6,45.97 64.6,46.68 64.37,46.91 64.14,46.91 63.88,47.16 63.88,48.02 64.1,48.25 64.75,48.25 64.92,48.07 64.92,47.53 65.08,47.37 66.64,47.37 66.79,47.53 66.79,48.09 66.95,48.25 68.56,48.25 68.71,48.09 68.71,47.53 68.86,47.37 70.27,47.37 70.42,47.53 70.42,48.09 70.57,48.25 72.44,48.25 72.62,48.42 72.62,48.77 72.8,48.95 73.28,48.95 73.46,48.77 73.46,48.4 73.64,48.23 v1(74,48.23)
  BOTTOM w0.089: v1(39.72,46.68) 39.42,46.68 39.27,46.52 39.27,46.34 U1.AP36
  BOTTOM w0.102: v1(81.54,60.98) 81.25,60.68 81.25,60.12 81.36,60.01 81.59,60.01 81.69,59.91 81.69,59.46 81.3,59.07 81.06,59.07 80.73,59.4 80.57,59.4 80.23,59.06 80.23,55.89 80.77,55.35 80.77,54.4 80.47,54.1 80.47,53.58 80.72,53.33 80.72,52.39 79.12,50.79 78.84,50.79 78.72,50.66 78.72,50.49 78.61,50.39 78.34,50.39 78.23,50.49 78.23,50.66 78.13,50.77 77.93,50.77 77.83,50.66 77.83,50.49 77.73,50.39 77.47,50.39 77.37,50.49 77.37,50.66 77.27,50.77 77.04,50.77 76.94,50.66 76.94,50.49 76.84,50.39 76.63,50.39 76.53,50.49 76.53,50.69 76.43,50.79 76.24,50.79 75.59,50.15 75.59,49.97 75.3,49.67 75.12,49.67 74.86,49.41 74.86,49.23 74.66,49.03 74.48,49.03 74,48.55 v1(74,48.23) 74,47.81 74.07,47.74 74.07,43.71 74.31,43.46 76.65,43.46 78.58,41.54 78.58,40.99 79.16,40.41 79.16,39.95 79.26,39.84 79.43,39.84 79.53,39.74 79.53,39.51 79.43,39.41 79.26,39.41 79.16,39.31 79.16,38.47 79.26,38.37 79.54,38.37 79.65,38.27 79.65,37.48 79.75,37.38 80.27,37.38 80.37,37.28 80.37,35.7 80.76,35.31 80.76,34.03 80.89,33.9 81.23,33.9 81.33,33.8 81.33,32.88 v1(81.13,32.68)
