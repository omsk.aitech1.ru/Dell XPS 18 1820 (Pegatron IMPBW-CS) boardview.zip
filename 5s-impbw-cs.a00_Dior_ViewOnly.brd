# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VA_HG_D: length 26.9
  TOP w0.635: v1(112.64,45.83) 111.84,46.63 111.84,55.54 113.03,56.74 113.41,56.74 114.23,57.55 115.57,57.55 115.95,57.93 115.95,60.65 116.77,61.46 116.77,62.4 117.35,62.98 v2(117.71,62.98) 118.84,64.12 v1(122,64.12)
  BOTTOM w0.635: PR151.1 112.65,46.32 112.65,45.84 v1(112.64,45.83)
+3VA_IN: length 0.7
  TOP w0.508: v2(114.89,42.74) v1(114.17,42.74)
+3VA_LG_D: length 45.1
  TOP w0.254: v2(122.4,66.11) 122.4,65.83 v1(121.62,65.05)
  IN3 w0.635: v1(121.62,65.05) 121.62,65.73 121.16,66.18 120.6,66.18 116.16,61.74 116.16,59.01 115.15,58.01 112.22,58.01 111.33,57.12 111.33,56 111.79,55.54 111.79,45.71 113.89,43.6 117.35,43.6 119.6,41.35 121.11,41.35 121.71,41.95 v1(121.71,42.55)
  BOTTOM w0.203: PU6.11 122.6,64.55 122.09,65.05 v1(121.62,65.05)
  BOTTOM w0.635: v1(121.71,42.55) 122.16,43 PR156.1
+3VA_PHASE_R: length 23.7
  TOP w0.635: v1(120.39,63.22) 120.39,62.72 119.81,62.15 119.08,62.15 118.49,61.56 118.49,61.26 117.3,60.06 v2(117.3,59.2) 117.3,57.1 115.54,55.34 113.44,55.34 113.11,55.01 113.11,47.26 114.77,45.6 v1(115.46,45.6)
+3VA_R1_HG_D: length 5
  BOTTOM w0.254: PR151.2 111.83,44.43 109.34,44.43 108.94,44.04 v2(108.94,42.69)
+3VA_R1_LG_D: length 4.5
  BOTTOM w0.152: PR156.2 122.16,44.91 122.48,44.59 122.89,44.59 123.06,44.42 123.06,42.61 v2(122.45,42)
+3VA_SN_C: length 1.6
  BOTTOM w0.102: v2(118.21,42.31) 117.46,43.06 PR214.2
+3VA_SPI: length 18.5
  BOTTOM w0.457: R218.1 114.25,64.99 R221.1 113.78,65.06 U11.8 112.47,64.28 111.2,63.01 110.01,63.01 109.12,62.12 107.14,62.12 106.3,62.96 106.3,63.95 105.63,64.62 R219.1 104.69,64.62 104.27,65.04 104.27,66.31 104.74,66.78 R220.1
  BOTTOM w0.508: v2(112.83,63.49) 113.47,64.13 R218.1
+3VM_SPI1_WP#: length 10
  BOTTOM w0.508: F3U1.3 141.75,87.72 138.44,84.41 F3R9.2 137.57,84.4 F3R2.2 136.84,82.96 v2(136.35,83.46)
+3VM_VCCPSPI: length 16.2
  TOP w0.254: PR37.2 33.76,76.32 33.72,76.28 PR228.2 34.09,75.01 34.33,74.77 34.33,72.93 34.39,72.87 34.39,71.8 34.16,71.56 PC17.1 33.54,71.27 33.54,70.82 33.38,70.66 v1(32.83,70.66)
  IN3 w0.203: v1(32.09,63.47) 32.06,63.47 31.63,63.9 31.63,66.67 31.95,67 31.95,68.82 32.83,69.7 v1(32.83,70.66)
  BOTTOM w0.254: v1(32.09,63.47) 32.06,63.47 31.81,63.22 U1.Y8
+3VS_VCC: length 30.4
  TOP w0.508: v1(28.21,77.28) 28.21,78.09 v2(27.89,78.41)
  IN3 w0.203: 30.36,62.57 29.43,62.57 28.75,63.26 28.75,66.49 28.92,66.66 29.74,66.66 30.07,66.34 30.07,65.91 29.7,65.54 29.7,63.23 30.36,62.57 ; 30.36,62.57 30.43,62.57
  IN3 w0.381: 30.43,62.57 31.14,63.29 v1(31.14,63.5) ; 28.92,66.66 28.92,66.99 28.47,67.43 28.47,70.43 28.21,70.69 28.21,73.77 27.57,74.41 27.57,76.81 28.04,77.28 v1(28.21,77.28)
  BOTTOM w0.254: U1.W9 31.12,62.79 31.12,63.37 31.14,63.4 v1(31.14,63.5) 31.04,63.4 30.84,63.4 U1.V8
  BOTTOM w0.381: PC32.1 26.27,77.9 26.27,77.11 PR45.1 26.87,77.04 26.87,77.21 27.05,77.39 27.06,77.39 27.1,77.44 28.06,77.44 v1(28.21,77.28)
+3VSUS_VCCPUSB: length 59.2
  TOP w0.508: v2(51.74,76.19) 51.74,76.93 51.72,76.95 v1(51.72,77.06)
  IN1 w0.203: 30.68,67.32 31.25,67.32 31.62,66.94 31.62,63.08 31.91,62.79 31.91,61.91 v1(31.62,61.62) 31.62,62.26 30.65,63.22 30.65,66.01 30.39,66.28 30.39,67.03 30.68,67.32
  IN1 w0.406: v1(31.31,74.45) 31.28,74.45 30.67,73.84 30.67,72.98 30.68,72.98 30.68,67.32
  IN2 w0.406: v1(51.72,77.06) 50.13,77.06 49.63,77.55 49.63,77.85 49.32,78.15 48.09,78.15 47.89,77.96 43.48,77.96 42.6,77.08 40.36,77.08 39.02,78.41 38.38,78.41 38.18,78.21 38.18,77.46 37.82,77.11 34.25,77.11 33.5,76.36 33.5,75.86 32.12,74.47 31.34,74.47 v1(31.31,74.45)
  BOTTOM w0.254: U1.AE21 34.44,56.22 U1.AE20 33.78,56.63 33.64,56.76 33.64,56.8 33.36,57.09 33.36,57.74 33.29,57.8 33.15,57.94 32.67,58.42 31.62,59.47 v1(31.62,61.62) 32.09,62.09 U1.AA9 U1.AC9
  BOTTOM w0.508: PR42.2 50.23,80.21 50.23,78.93 PC27.1 51.72,77.45 v1(51.72,77.06)
+5V: length 174.7
  TOP w0.508: v1(175.36,66.39) 175.36,66.85 R315.1 ; v1(131.68,63.92) 132.13,64.38 132.13,67.42 132.59,67.89 135.79,67.89 T34.1 139.55,71.65 142.27,71.65 142.94,72.32 142.94,73.05 143.6,73.71 143.6,74.55 142.15,76 142.15,76.91 144.33,79.09 144.33,81.03 142.42,82.94 F3R13.1 ; v1(4.24,66.43) 5.32,65.35 5.32,58.3 4.05,57.03 4.05,49.53 1.73,47.21 v1(1.73,33.77) 1.73,22.62 4.7,19.65 4.7,12.77 6.92,10.55 PR103.1
  IN1 w0.762: 175.41,67.05 172.01,67.05 171.1,66.13 168.3,66.13 167.49,66.95 167.06,66.95
  IN1 w1.016: 167.06,66.95 167.06,67.43 168.26,68.64 175.48,68.64 177.22,66.9
  IN1 w1.778: 164.11,64.53 164.64,64.53 167.06,66.95 ; 159.31,61.33 161.85,63.87
  IN2 w0.508: 132.31,60.16 132.31,63.29 v1(131.68,63.92)
  IN2 w1.016: 173.69,65.19 171.63,63.14 171.63,61.59 170.97,60.93 170.97,58.97 ; 172.13,39.1 172.13,45.67 170.64,47.16 170.64,52.82
  IN3 w1.778: 149.79,49.19 151.28,50.69 151.28,58.54 153.52,60.77 156.85,60.77
  BOTTOM w0.203: PR134.1 3.8,33.35 PU5.2
  BOTTOM w0.381: v1(1.73,33.77) 1.98,34.03 2.63,34.03 2.85,34.24 2.85,34.26 PC92.1 3.7,34.37 PR134.1
  vias: v1(132.31,59.12) v1(159.18,60.44) v1(171.64,38.86) v1(171.67,38.15) v1(174.73,66.36) v1(178.13,64.97) v1(178.13,64.33) v3(17.12,65.98) v3(131.56,60.52) v3(132.03,57.12) v3(145.19,48.51) v3(145.19,47.57) v3(158.88,61.18)
+5V_DUAL: length 84
  TOP w0.457: C176.1 8.71,76.76 8.71,76.79 v1(9.59,77.67)
  TOP w0.508: v3(174.83,70.17) 174.83,69.87 175.38,69.32 R321.1
  IN1 w0.762: v3(174.83,70.17) 174.26,70.17 173.76,70.68 170.15,70.68 169.84,70.38 165.63,70.38 162.78,67.52 159.79,67.52 159.26,66.99 159.26,65.96 157.93,64.62 147.15,64.62 145.59,66.18 145.59,69.12 143.68,71.04 132.87,71.04 131.8,72.1 v1(130.74,72.1)
  IN2 w0.762: v3(177.01,87.88) 176.38,87.24 176.38,82.92 176.55,82.75 176.55,81.72 175.21,80.38 175.21,77.39 174.74,76.92 174.74,73.82 175.58,72.98 175.58,70.73 175.03,70.17 v3(174.83,70.17)
  BOTTOM w0.279: CON11.14 183.25,86.52 183.07,86.69
  BOTTOM w0.762: v3(177.01,87.88) 177.15,87.74 179.34,87.74 179.42,87.82 181.95,87.82 183.07,86.69
  vias: v1(9.61,75.61) v1(38.38,84.52) v1(39.02,84.52) v1(130.8,61.38) v1(130.8,60.75) v1(131.05,62.18) v1(131.69,62.18) v2(39.42,85.39) v3(9.35,73.58) v3(131.56,61.42)
+5V_DUAL_G_B: length 5.9
  TOP w0.254: PQ30.3 131.26,56.48 131.78,56.48 132.21,56.05 PR206.2 132.66,56.76 PC196.1 133.04,57.12 134.06,56.1 v2(134.06,55.34)
+5V_G_B: length 6.1
  TOP w0.254: v2(127.62,55.19) v1(127.62,56.08)
  BOTTOM w0.254: PQ24.1 129.18,58.28 128.84,57.94 PC200.1 ; PC200.1 127.83,57.94 127.62,57.74 v1(127.62,56.08) ; PC200.1 128.3,58.74 PR195.2
+5V_LCD: length 75.1
  TOP w0.508: R318.1 169.2,65.64 168.48,64.91 168.48,63.42 v1(168.73,63.16) ; 172.29,37.13 173.18,37.13 v2(173.64,37.58) ; C142.1 147.97,10.42 ; C143.1 146.87,10.42
  IN2 w0.508: v1(171.1,37.15) 170.88,37.37 170.88,39.56 171.24,39.91 171.24,45.29 169.49,47.03 169.49,48.08 168.35,49.22 168.35,58.62 169.27,59.53 169.27,60.02 168.73,60.55 v1(168.73,63.16)
  BOTTOM w0.254: v1(147.65,10.76) 147.75,10.66 P2.1 ; v1(148.29,10.76) 148.25,10.72 P2.2
  BOTTOM w1.016: 170.42,36.67 169.17,36.67 167.77,35.27 158.57,35.27 149.63,26.33 149.63,20.24 146.76,17.37 146.76,14.88
  vias: v1(146.51,14.44) v1(147.27,14.44) v1(171.12,36.52)
+5V_SATA: length 5.6
  TOP w0.508: 183.03,63.37 R232.1 ; R232.1 184.1,63.37 ; R232.1 183.57,63.88 ; R231.2 v2(181.02,62.76)
  TOP w0.635: 186.07,64.78 CON3.P9 ; 186.07,62.24 CON3.P7 ; 186.07,63.51 CON3.P8
+5VA: length 469.5
  TOP w0.254: R345.1 162.11,41.96 162.38,42.23 163.07,42.23 v1(163.68,41.62)
  TOP w0.457: PR67.1 141.61,38.14 142.42,37.33 142.42,36.16 140.49,34.23 139.45,34.23 136.04,30.83 v1(135.46,30.83) 135.46,35.98 PR68.1
  TOP w0.508: v1(135.46,30.83) 134.44,30.83 133.91,30.29 133.91,27.12 128.27,21.48 v2(122.36,21.48) 119.97,21.48 118.8,20.31 112.42,20.31 110.64,18.53 110.64,17.14 106.99,13.48 105.02,13.48 103.58,12.04 103.58,11.37 101.06,8.85 95.07,8.85 92.98,10.94 v1(92.69,10.94) ; D18.2 156.78,40.28 156.76,40.29 v1(156.76,40.28) ; PR67.1 142.19,41.08 142.19,42.13 143.89,43.83 v1(143.89,45.15) ; v1(9.7,78.95) 9.68,78.92 9.68,78.87 C431.1
  IN2 w0.508: v1(163.68,41.62) 165.15,43.1 165.15,47.44 167.11,49.4 167.11,67.68 168.37,68.94 175.21,68.94 176.63,70.36 v1(176.63,74.46) 176.63,75.07 175.95,75.76 175.95,78.81 177.75,80.61 177.75,87.09 177.95,87.29 v1(177.95,88.49) 177.7,88.74 174.7,88.74 173.13,87.16 168.86,87.16 167.92,88.1 159.27,88.1 153.58,82.41 149.25,82.41 145.43,86.24 142.01,86.24 141.56,86.69 133.59,86.69 133.13,86.24 130.74,86.24 129.78,85.29 117.9,85.29 117.04,86.15 116.18,86.15 116.18,86.15 115.66,86.15 115.61,86.15 115.06,86.7 115.06,87.89 113.31,89.64 69.05,89.64 67.91,88.5 64.8,88.5 63.93,87.62 59.39,87.62 59.01,87.24 57.5,87.24 56.79,87.95 55.01,87.95 54.2,88.76 52.62,88.76 51.85,87.99 40.52,87.99 39.49,89.03 24.13,89.03 21,85.89 17.79,85.89 17.24,85.34 16.67,85.34 15.62,84.29 13.97,84.29 12.19,82.52 12.19,81.44 v1(9.7,78.95) ; v1(143.89,45.15) 144.81,45.15 146.66,47.01 146.66,47.92 147.09,48.35 148.36,48.35 149.58,49.57 149.58,60.7 144.1,66.18 144.1,69.03 143.18,69.94 136.35,69.94 135.57,70.72 131.31,70.72 130.54,71.48 127.66,71.48 126.99,70.81 125.63,70.81 123.93,69.11 123.93,67.99 123.5,67.56 v1(123.5,65.57)
  BOTTOM w0.254: v1(9.7,78.95) 9.48,78.95 9.28,78.74 CON10.22
  BOTTOM w0.279: v1(177.95,88.49) 178.82,88.49 179.55,89.22 183.67,89.22 184.25,88.64 CON11.16
  BOTTOM w0.457: R310.2 175.95,73.78 v1(176.63,74.46)
  BOTTOM w0.508: v1(59.29,9.62) 60.76,9.62 61.65,10.51 63.65,10.51 64.55,11.41 64.95,11.41 65.46,11.41 67.41,13.36 71.22,13.36 71.93,12.65 73.64,12.65 75.08,11.22 92.41,11.22 v1(92.69,10.94) ; v1(135.46,30.83) 135.46,30.79 138.88,27.37 147.31,27.37 153.54,33.61 153.54,35.53 156.76,38.74 v1(156.76,40.28) 162.33,40.28 v1(163.68,41.62)
+5VA_FB1_A: length 21
  TOP w0.203: PC127.1 PR147.1 123.81,56.76 123.76,56.71 PC128.1
  TOP w0.254: v2(123.76,55.29) PC128.1 123.26,56.34 123.04,56.56 v1(122.18,56.56)
  IN1 w0.254: v1(135.49,57.32) 135.49,57.01 133.81,55.34 132.28,55.34 131.78,55.85 131.42,55.85 129.58,57.69 125.03,57.69 123.9,56.56 v1(122.18,56.56)
  BOTTOM w0.152: v1(135.49,57.32) 135.06,57.75 PJP12.1
+5VSB: length 205.8
  TOP w0.254: v2(132.28,53.51) v1(133.1,53.51)
  TOP w0.508: C432.1 9.63,81.06 v1(9.63,80.43) ; v1(130.86,83.08) 130.86,78.73 131.19,78.4 131.19,73.09 131.68,72.61 131.68,70.81 v1(131.01,70.15)
  IN1 w0.508: v1(134.11,88.92) 132.99,90.04 66.81,90.04 66.52,89.76 v1(66.52,89.74)
  IN2 w0.508: v1(66.52,89.74) 66.22,90.04 52.36,90.04 51.32,89.01 43.61,89.01 42.57,90.04 23.71,90.04 21.48,87.81 18.27,87.81 16.82,86.36 16.24,86.36 15.28,85.4 13.62,85.4 11.18,82.95 11.18,81.91 9.7,80.43 v1(9.63,80.43) ; v1(105.21,63.92) 106.15,64.87 119.66,64.87 121.03,63.5 122.99,63.5 124.16,64.66 124.16,66.28 125.3,67.43 126.33,67.43 126.81,67.91 126.81,68.56 126.61,68.76 126.61,69.39 128.05,70.83 130.33,70.83 v1(131.01,70.15) 130.58,70.15 129.19,68.75 129.19,67.53 129.01,67.35 129.01,63.72 129.49,63.24 v1(129.49,61.54) 129.49,61.52 129,61.52 128.53,61.05 128.53,58.28 129.1,57.71 v3(129.1,56.32)
  BOTTOM w0.254: v1(9.63,80.43) 9.63,79.7 9.17,79.24 CON10.21
  BOTTOM w0.508: PR52.1 66.49,90.05 66.52,90.02 v1(66.52,89.74) ; PD6.1 v1(129.49,61.54) ; v1(134.11,88.92) 134.11,87.09 130.86,83.84 v1(130.86,83.08)
  vias: v3(129.1,55.29) v3(129.9,55.67)
+5VSB_BST1_D: length 1.1
  TOP w0.254: v2(129.06,65.99) 128.82,65.75 v1(128.03,65.75)
+5VSB_BST_D: length 1.4
  TOP w0.254: v1(125.25,64.66) 124.72,64.66 124.66,64.71 v2(123.9,64.71)
+5VSB_CS_A: length 3.4
  TOP w0.203: v1(124.71,61.03) 124.77,60.97 PR149.2
  TOP w0.254: v1(124.71,61.03) 124.43,61.31 v2(123.09,61.31)
  BOTTOM w0.203: PU6.1 124.2,61.23 124.4,61.03 v1(124.71,61.03)
+5VSB_EN_A: length 5.1
  BOTTOM w0.203: PR154.2 124.91,59.07 124.91,59.36 v2(124.36,59.91) 124.77,60.32 125.15,60.32 PC136.1 125.38,61.63 124.98,62.03 PU6.20
+5VSB_FB_A: length 6.3
  TOP w0.203: v1(124.01,60.68) 124.01,60.3 123.81,60.1 PR148.1 123.29,59.22 123.29,58.49 PR147.2 PC127.2
  TOP w0.254: PR147.2 123.46,57.61 123.29,57.61 v2(122.81,57.13)
  BOTTOM w0.203: PU6.2 123.8,60.9 v1(124.01,60.68)
+5VSB_HG_D: length 23.9
  TOP w0.254: v1(124.74,64.12) 123.82,64.12 123.04,63.34 v2(121.46,63.34)
  IN3 w0.635: v1(124.74,64.12) 124.88,63.97 126.42,63.97 126.77,63.62 126.77,61.97 125.4,60.6 125.4,57.93 124.54,57.07 124.54,47.94 v1(124.88,47.6)
  BOTTOM w0.635: v1(124.88,47.6) 125.21,47.27 PR140.1
+5VSB_IN: length 45.8
  IN3 w0.635: v1(126.61,42.87) 125,42.87 120.96,46.91 113.62,46.91 112.96,47.57 112.96,54.91 113.44,55.39 115.7,55.39 117.12,56.81 118.55,56.81 120.4,58.66 120.4,60.57 121.87,62.04 121.87,62.37 123.19,63.7 123.19,64.84 122.81,65.22 122.81,68.01 v1(122.94,68.14)
  BOTTOM w0.254: 121.86,69.22 123.14,69.22 v2(123.26,69.11)
  BOTTOM w0.508: PR138.1 121.86,69.22 v1(122.94,68.14)
+5VSB_PHASE_R: length 24
  TOP w0.254: v2(125.22,63.49) 125.22,63.33 v1(125.72,62.84)
  IN3 w0.635: v1(128.42,46.17) 124.51,46.17 123.27,47.42 123.27,58.54 122.66,59.15 122.66,60.7 124.8,62.84 v1(125.72,62.84)
+5VSB_R1_HG_D: length 0.8
  TOP w0.508: v1(126.32,45.31) 125.96,44.95 v2(125.66,44.95)
+5VSB_R1_LG_D: length 4.2
  BOTTOM w0.254: v2(135.1,42.56) 135.59,42.56 136.27,43.25 136.27,44.31 136.12,44.47 136.12,44.75 PR143.2
+5VSB_SN_C: length 0.7
  TOP w0.508: v2(132.01,44.14) v1(131.5,43.63)
+5VSB_VIN_C: length 57.5
  TOP w0.254: R437.1 124.5,69.63 127.43,69.63 127.93,69.13 v1(127.93,68.31) ; PD8.2 163.57,65.03 v2(163.02,64.48) 164.03,63.47 164.75,63.47 165.55,62.66 PQ34.3 164.57,61.86 164.28,62.15 161.72,62.15 161.22,61.65 v1(161.22,61.46)
  IN1 w0.254: v1(127.93,68.31) 127.93,68.25 128.36,67.82 128.77,67.82 129.06,68.11 129.06,68.79 129.29,69.02 131.69,69.02 132.23,68.47 138.01,68.47 139.34,69.8 143.13,69.8 143.97,68.97 143.97,66.08 145.65,64.4 v1(145.65,62.38)
  IN3 w0.254: v1(161.22,61.46) 160.4,62.27 145.76,62.27 v1(145.65,62.38)
+5VSB_VIN_C_R: length 78
  TOP w0.508: v1(121.72,68.22) 121.82,68.22 R437.2 ; v1(161.93,59.91) v2(161.93,60.67)
  IN1 w0.508: v1(161.93,59.91) 161.42,59.91 160.12,58.62 155.63,58.62 153.01,56 153.01,51.93 148.46,47.39 v1(147.58,47.39)
  IN2 w0.508: v1(121.72,68.22) 121.72,70.12 122.53,70.93 124.54,70.93 125.05,71.44 126.44,71.44 127.73,72.72 131.89,72.72 133.15,71.47 135.69,71.47 136.6,70.55 143.71,70.55 144.71,69.56 144.71,66.82 150.24,61.28 150.24,49.26 148.37,47.39 v1(147.58,47.39)
  BOTTOM w0.508: 121.77,67.34 121.77,68.17 v1(121.72,68.22)
+5VSB_VO1_A: length 17.6
  TOP w0.254: v2(124.79,66.75) v1(125.5,66.75)
  IN1 w0.254: v1(135.79,59.02) 134.04,59.02 133.58,58.56 131.73,58.56 130.07,60.22 130.07,62.3 125.63,66.75 v1(125.5,66.75)
  BOTTOM w0.152: PJP11.1 135.6,58.83 v1(135.79,59.02)
  BOTTOM w0.254: v1(125.5,66.75) 125.7,66.75 125.88,66.92 PR146.2
+5VSB_VO_A: length 5.6
  TOP w0.254: v2(127.15,67.78) 127.15,67.56 v1(126.34,66.75)
  BOTTOM w0.203: PC124.1 124.81,66.08 123.85,65.12 123.85,64.53 123.8,64.47 PU6.14
  BOTTOM w0.254: PC124.1 125.25,66.08 125.25,66.07 PR146.1 126.34,66.54 v1(126.34,66.75)
+5VSBLG_D: length 34
  TOP w0.254: v1(124.86,65.37) 125.58,65.37 v2(125.78,65.17)
  IN3 w0.635: v1(124.86,65.37) 125.3,65.8 126.67,65.8 127.69,64.79 127.69,60.67 128.35,60.01 128.35,59.2 131.32,56.23 132.54,56.23 133.08,56.77 133.78,56.77 135.21,55.34 136.07,55.34 136.55,54.86 136.55,48.68 136.78,48.45 136.78,47.19 135.28,45.69 v1(135.28,44.64)
  BOTTOM w0.203: PU6.15 124.2,64.45 124.33,64.58 124.33,64.84 v1(124.86,65.37)
  BOTTOM w0.635: PR143.1 v1(135.28,44.64)
+12V_+19V: length 348.9
  TOP w0.254: Q40.5 136.83,15.46 137.21,15.08 137.21,14.5 136.91,14.19 v1(136.37,14.19) v2(137.01,13.55) ; Q40.2 v1(135.41,15.46)
  TOP w0.406: v1(168.61,59.76) 167.38,60.98 R432.1
  TOP w0.508: v1(126.19,88.41) 124.56,90.03 98.86,90.03 98.3,89.48 98.3,88.88 v1(97.97,88.55)
  TOP w0.635: 40.57,88.83 19.36,88.83 v3(19.19,89.01)
  IN1 w0.508: v1(178.67,89.11) 174.61,89.11 174.03,88.52 170.91,88.52 170.6,88.83 150.7,88.83 150.44,88.57 143.15,88.57 141.91,87.33 133.39,87.33 132.48,88.24 128.89,88.24 128.35,87.7 126.52,87.7 126.19,88.03 v1(126.19,88.41) ; v1(42.57,88.83) 52.39,88.83 53.6,90.03 58.8,90.03 59.92,88.92 59.92,87.85 60.2,87.57 63.68,87.57 65.18,89.07 69.64,89.07 v1(69.93,88.78) 69.93,88.26 69.27,87.6 68.68,87.6 68.4,87.32 68.4,85.64 v1(68.62,85.42) 69.78,86.58 72.59,86.58 75.3,89.29 97.39,89.29 97.97,88.71 v1(97.97,88.55) ; v3(19.19,89.01) 19.01,89.01 16.81,86.81 10.58,86.81 10.23,87.16 v1(10.23,87.15)
  IN2 w0.254: v3(19.19,89.01) 18.16,90.03 12.55,90.03 10.9,88.38 10.06,88.38 9.59,87.91 v1(9.59,87.14)
  IN2 w0.508: v1(178.67,89.11) 178.64,89.08 178.64,87.04 178.4,86.8 178.4,80.4 176.56,78.56 176.56,76.01 177.27,75.3 177.27,69.99 175.6,68.33 171.07,68.33 170.16,67.42 170.16,66.01 168.11,63.96 168.11,60.31 168.61,59.82 v1(168.61,59.76) 167.72,58.87 167.72,48.86 168.88,47.7 168.88,46.85 168.89,46.85 168.89,46.78 170.63,45.04 170.63,41.11 169.5,39.98 169.5,38.68 169.43,38.62 169.43,33.84 172.75,30.52 172.75,13.95 168.33,9.53 141.14,9.53 136.48,14.19 v1(136.37,14.19)
  BOTTOM w0.254: v1(136.37,14.19) 135.69,14.19 135.41,14.47 v1(135.41,15.46)
  BOTTOM w0.356: SQ2.5 SQ2.2 74.98,88.21 75.31,87.88 75.31,87.39 74.37,86.45 74.37,85.22 73.92,84.76 72.55,84.76 71.88,84.09 69.95,84.09 v1(68.62,85.42) ; 69.93,88.64 70.36,88.21 SQ1.5 ; 69.93,88.64 v1(69.93,88.78) ; 69.93,88.64 69.5,88.21 SQ1.2
  vias: v1(41.3,88.84) v1(41.94,88.83)
+15VSB: length 80.1
  TOP w0.254: v1(130.63,20.67) 131.31,20.67 PR203.1 ; v1(128.13,66.59) 127.84,66.59 127.29,66.04 v2(127.29,66.03) 127.29,65.18 127.28,65.17 PR209.1
  IN2 w0.254: v1(130.63,20.67) 128.27,20.67 121.7,27.23 121.7,30.76 v1(121.49,30.98) 121.49,35.27 125.18,38.97 125.18,45.59 124.38,46.39 124.38,56.44 126.98,59.04 126.98,65.43 v1(128.13,66.59)
  BOTTOM w0.254: v1(121.49,30.98) 121.49,30.75 120.96,30.22 119.66,30.22 119.14,30.74 112.19,30.74 108.52,34.41 PR236.1 ; PC129.1 127.88,66.34 v1(128.13,66.59) 128.47,66.93 128.47,67.28 128.65,67.45 129.69,67.45 130.07,67.07 130.14,67.07 PD7.2
+15VSB_VCLK: length 4.5
  TOP w0.254: v1(125.66,62.12) 125.05,62.12 v2(124.74,61.82)
  BOTTOM w0.203: v1(125.66,62.12) 125.48,62.12 125.17,62.43 PU6.19
  BOTTOM w0.254: v1(125.66,62.12) 125.88,61.9 PC126.1 PC123.2
+15VSB_VCLK1: length 5
  BOTTOM w0.254: PD6.3 130.81,62.98 130.56,62.73 130.56,61.87 129.73,61.04 129.07,61.04 128.66,60.63 PC123.1
+15VSB_VCLK2: length 6.1
  BOTTOM w0.508: PD7.1 131.32,67.4 131.95,66.77 131.95,65.47 131.34,64.86 PC125.1 130.76,64.05 130.34,63.63 PD6.2
+15VSB_VCLK3: length 5.4
  BOTTOM w0.254: PC126.2 128.7,62.67 128.7,66.28 PD7.3
+19V_B: length 4.8
  BOTTOM w0.254: v2(55.7,87.7) 55.65,87.7 PC190.1
  BOTTOM w0.508: PQ28.1 53.54,89.37 53.84,89.67 PR200.2 55.16,89.43 54.7,88.97 PC190.1
+19V_BL_F:
  vias: v1(165.69,10.81) v1(165.69,10.18) v1(166.32,10.18) v1(166.96,10.18) v2(166.02,9.47)
+19V_GATE: length 4.1
  BOTTOM w0.356: PR197.2 51.5,87.23 51.28,87.44 50.37,87.44 50.01,87.8 50.01,88.21 49.75,88.47 49.13,88.47
+19V_GATE1: length 8.7
  BOTTOM w0.356: PQ25.2 49.84,85.44 50.12,85.16 v2(50.52,85.16) 51.08,85.16 51.39,85.46 51.74,85.46 52.11,85.84 52.11,87.51 51.2,88.42
+DVDD: length 7.3
  TOP w0.457: v1(149.48,7.97) 150.52,9.01 150.85,9.01 v2(151.08,9.24) 151.35,9.51 151.35,9.92 152.37,10.94 153.04,10.94 153.45,11.35 R284.1
  BOTTOM w0.254: v1(149.48,7.97) 149.75,8.24 P2.5
+VCC_RTC: length 158.8
  TOP w0.381: R74.1 49.04,69.33 48.88,69.18 R73.1 ; PC10.1 59.63,76 60.35,76.73 62.36,76.73 63.07,77.44 68.35,77.44 69.13,76.66 77.56,76.66 v1(78.32,75.9) ; PC10.1 57.41,77.02 PC8.1 PC9.1 ; PC10.1 57.14,75.74 57.14,75.56 56.83,75.25 v1(56.47,75.25) ; v1(35.68,61.75) 35.93,61.99 40.64,61.99 40.98,62.33 40.98,62.78 41.49,63.29 42.41,63.29 42.95,63.83 42.95,64.46 44.92,66.43 45.49,66.43 46.92,67.85 R77.1 48.33,68.03 48.88,68.58 R73.1 ; R73.1 50.75,68.8 51.11,69.16 v1(51.11,69.49) 51.39,69.77 51.39,70.96 52.05,71.62 R75.1 52.41,71.99 52.83,72.41 52.83,73.96 v1(52.68,74.11)
  IN1 w0.381: v1(52.68,74.11) 53.01,74.43 54.5,74.43 55.32,75.25 v1(56.47,75.25)
  IN3 w0.381: 101.75,76.6 101.75,76.27 101.26,75.77 100.53,75.77 100.12,75.36 100.12,75.14 98.26,73.28 95.93,73.28 94.25,71.6 92.97,71.6 92.58,71.21 90.32,71.21 89.77,71.77 87.28,71.77 85.73,73.32 80.06,73.32 78.32,75.06 v1(78.32,75.9) ; 101.75,76.6 v1(101.75,76.64) ; 101.75,76.6 102.51,75.84 106.23,75.84 106.3,75.91 109.93,75.91 111.18,74.66 115.86,74.66 116.66,75.46 138.89,75.46 139.68,74.67 143.71,74.67 144.09,74.29 154.25,74.29 154.93,74.97 158.49,74.97 160.09,76.57 161.6,76.57 v1(163.22,78.2)
  BOTTOM w0.178: U10.3 99.65,76.53 99.65,76.53 100,76.53 100,76.53 100.27,76.53 100.56,76.24
  BOTTOM w0.254: v1(35.68,61.75) 35.3,62.13 U1.AG10
  BOTTOM w0.381: v2(50.38,70.35) PR2.1 50.88,69.26 v1(51.11,69.49) ; v1(163.22,78.2) 164.63,79.61 C48.1 165.53,79.61 165.59,79.55 D1.3 ; 100.56,76.24 101.33,76.24 101.73,76.64 v1(101.75,76.64)
+VCCDSW: length 37.2
  TOP w0.254: PR44.1 54.93,70.03 55.09,70.2 55.09,70.63 55.24,70.78 PC31.1 55.02,71.78 v1(55.02,71.92) 55.2,72.1 v2(55.2,72.92)
  IN2 w0.305: v1(55.02,71.92) 55.02,70.78 58.09,67.71 58.09,64.99 57.21,64.1 56.41,64.1 55.98,64.53 55.55,64.53 54.56,63.55 41.01,63.55 40.95,63.61 36.82,63.61 36.23,63.02 v1(36.23,62.67)
  BOTTOM w0.254: v1(36.23,62.67) 36.23,62.39 U1.AH10
+VCCIO_OUT: length 31.5
  TOP w0.254: v1(10.92,12.82) 10.92,12.9 10.92,12.89 PC73.1
  IN2 w0.254: v1(14.66,31.79) 13.61,30.74 13.61,17.07 10.92,14.38 v1(10.92,12.82)
  BOTTOM w0.254: PR100.1 v1(10.92,12.82) 10.69,12.59 10.69,11.57 10.43,11.31 10.43,10.83 10.76,10.49 11.56,10.49 PR98.1 PR99.1 v2(13.24,9.59)
  BOTTOM w0.508: HR33.2 14.22,31.67 14.54,31.67 v1(14.66,31.79) 15.03,32.16 HR21.1
+VCCIO_OUT_R: length 8.9
  BOTTOM w0.254: U1.A59 19.93,31.9 18.53,30.51 16.87,30.51 HC3.1 16.35,31.68 16.3,31.73 HR21.2 16.3,32.69 16.21,32.78 v2(14.12,32.78)
+VCCIO_OUT_XDP: length 25.9
  TOP w0.279: XDP1.43 77.78,4.67 77.57,4.87 77.57,8.65 77.78,8.86 XDP1.44 77.78,11.25 77.88,11.36 77.88,11.57 77.94,11.63 77.94,12 77.93,12.01 77.93,12.09 GC1.1
  TOP w0.508: GC1.1 78.73,12.6 79.19,13.06 79.19,14.58 78.82,14.94 76.27,14.94 v2(75.87,15.33) 75.67,15.54 73.15,15.54 72.55,16.13 72.35,16.13 71.2,17.29 71.2,17.79 70.07,18.91 68.98,18.91 HR34.2
+VCCIOA_OUT: length 5.9
  TOP w0.254: v2(21.88,52.09) 21.21,52.76 21.21,54.16 HR16.1 22.01,54.96 22.1,54.96 22.35,55.21 22.35,55.29 22.73,55.67 22.88,55.67 v1(23.32,56.1)
  BOTTOM w0.254: U1.E20 23.32,56.44 v1(23.32,56.1)
+VCCPRTCSUS: length 30.1
  TOP w0.254: v1(43.52,74.62) 43.52,74.43 43.8,74.15 45.29,74.15 45.75,74.6 45.75,75.01 PC6.1
  IN2 w0.254: v1(43.52,74.62) 42.99,74.08 40.72,74.08 40.48,74.32 36.86,74.32 35.95,73.42 35.95,72.69 34.37,71.11 34.37,67.22 34.59,67 34.59,62.04 35.68,60.95 v1(35.68,60.94)
  BOTTOM w0.254: U1.AH11 35.99,61.32 35.68,61.01 v1(35.68,60.94) ; PR33.2 43.73,73.91 43.01,73.91 PR36.2 42.9,74.44 43.35,74.44 v1(43.52,74.62) 43.52,75.47 v2(44.1,76.04)
+VCCRTCEXT: length 5.8
  TOP w0.203: PC18.1 32.64,68.22 32.49,68.06 32.49,67 33.1,66.39 33.1,66.29 v2(33.35,66.03) 33.5,65.88 33.5,64.58 33.96,64.12 v1(33.97,64.12)
  BOTTOM w0.254: U1.AE7 34.22,64.12 v1(33.97,64.12)
+VCCST: length 238.4
  TOP w0.254: v1(27.64,19.91) 27.64,19.35 26.39,18.1 26.39,10.74 v1(26.49,10.63) ; v1(34.44,55.57) 34.36,55.57 33.67,54.88 HC6.1 33.67,54.46 33.61,54.4 v1(33.61,53.97)
  IN1 w0.254: v1(25.93,19.91) v1(27.64,19.91) v1(28.91,19.91)
  IN2 w0.102: 40.54,56.08 38.18,56.08
  IN2 w0.508: 51.58,56.71 v1(51.61,56.73) 53.04,58.16 53.49,58.16 54.21,58.88 54.21,60.23 55.74,61.76 59.01,61.76 60.92,63.67 63.16,63.67 67.65,68.16 67.65,71.27 70.27,73.88 73.89,73.88 74.68,73.09 87.17,73.09 88.01,72.25 88.01,70.54 89.44,69.11 89.54,69.11 93.32,65.32 v1(94.34,65.32) ; v1(92.84,35.76) 94.26,35.76 95.35,34.66 95.35,17.59 99.85,13.09 v1(99.85,6.99)
  IN3 w0.254: v1(99.85,6.99) 98.87,6.99 95.42,3.54 49.75,3.54 v1(49.51,3.78)
  IN3 w0.508: v1(92.84,35.76) 93.07,35.98 93.07,52.24 94.72,53.89 94.72,61.76 93.35,63.14 93.35,64.99 93.68,65.32 v1(94.34,65.32)
  BOTTOM w0.203: U1.AC22 33.22,54.35 v1(33.61,53.97)
  BOTTOM w0.254: U1.AE23 34.44,54.77 34.03,55.17 U1.AE22 34.07,55.2 v1(34.44,55.57) ; v2(27.64,19.19) v1(27.64,19.91) 27.56,19.98 HR2.1 ; v1(49.51,3.78) 49.28,3.55 45.39,3.55 43.63,5.31 43.63,10.04 40.25,13.42 32.46,13.42 30.17,11.13 26.99,11.13 v1(26.49,10.63) ; HR22.1 v1(28.91,19.91) 29.26,19.55 29.26,18.85 HR23.1 ; v1(99.85,6.99) 99.71,6.85 HR47.1 98.98,7.37 99.11,7.51 GR24.1 99.11,8.74 98.94,8.91 GR25.1 ; v1(25.93,19.91) 25.93,22.01 26.24,22.32 GR1.1
  BOTTOM w0.508: HC5.1 52.14,58 HR32.2 52.37,57.49 v1(51.61,56.73)
+VDD_BATA_PACK: length 77.8
  TOP w0.254: v1(161.75,68.27) 161.75,67.76 162.07,67.44 PD8.4
  IN1 w0.254: v1(161.75,68.27) 161.65,68.17 154.89,68.17 153.18,66.45 148.28,66.45 147.4,67.33 147.4,70.42 144.54,73.27 142.53,73.27 142.34,73.47 138.85,73.47 138.13,72.74 v1(135.21,72.74)
  IN2 w0.254: v1(135.21,72.74) 135.23,72.74 136.93,71.04 144.02,71.04 145.19,69.87 145.19,67.31 150.73,61.78 150.73,49.06 v1(146.41,44.75)
  BOTTOM w0.254: PD3.1 145.01,42.13 145.82,42.94 145.82,44.16 v1(146.41,44.75)
  vias: v1(133.94,72.74) v1(134.57,72.74) v2(135.21,73.88)
AGND_EC: length 287.8
  TOP w0.102: v2(121.16,89.07) 120.63,89.07 v1(119.64,88.08)
  TOP w0.381: PRT1.2 114.7,18.36 115.23,18.89 120.3,18.89 122.12,20.72 128.28,20.72 134.55,26.98 v1(134.55,29.46)
  IN1 w0.254: v1(156.9,41.98) 156.72,41.8 154.75,41.8 151.43,38.49 144.78,38.49 136.33,30.04 134.8,30.04 134.55,29.79 v1(134.55,29.46) ; v1(157.46,65.75) 157.46,65.92 156.78,66.59 155.55,66.59 155.06,66.1 148.13,66.1 147.02,67.21 147.02,70.3 144.41,72.9 143.7,72.9 v1(143.56,72.76)
  IN1 w0.508: v1(81.43,85.08) 81.43,85.49 81.71,85.77 84.08,85.77 84.76,86.45 88.67,86.45 89.38,85.74 89.38,85.06 90.48,83.96 92.89,83.96 94.21,85.29 96.45,85.29 96.67,85.51 99.33,85.51 99.65,85.84 106.03,85.84 106.25,85.62 111.35,85.62 111.48,85.49 114.51,85.49 115.31,84.69 117.16,84.69 117.98,85.51 118.87,85.51 119.26,85.9 v1(119.26,86.63)
  IN2 w0.254: v1(157.46,65.75) 157.46,65.32 156.03,63.9 155.45,63.9 154.08,62.53 154.08,44.8 v1(156.9,41.98)
  IN2 w0.508: v1(119.64,88.08) 119.26,87.7 v1(119.26,86.63) ; v1(66.38,84.09) 66.37,84.08 61.87,84.08 61.26,83.47 56.03,83.47 55.49,84 51.72,84 51.19,84.53 47.45,84.53 46.81,83.88 39.5,83.88 39.07,83.46 31.77,83.46 31.62,83.31 26.73,83.31 24.39,80.96 22.37,80.96 19.5,78.1 18.44,78.1 17.17,76.83 17.17,74.36 16.92,74.11 16.92,70.2 v1(16.97,70.15)
  BOTTOM w0.178: 115.9,83.74 115.5,84.13 U10.75
  BOTTOM w0.254: v1(119.64,88.08) 119.64,87.8 119.91,87.52 122.12,87.52 123.88,89.27 127.61,89.27 128.4,88.49 128.4,82.95 130.02,81.32 136.78,81.32 137.06,81.04 137.06,77.92 137.99,76.99 137.99,75.97 139.51,74.45 141.37,74.45 141.85,74.93 143.07,74.93 143.56,74.44 v1(143.56,72.76)
  BOTTOM w0.457: C74.2 SP1.1 118.62,85.87 ; v1(119.64,88.08) 119.48,88.23 117.97,88.23 C83.2
  BOTTOM w0.508: 115.9,83.74 115.9,83.56 C73.2 118.47,82.25 119.44,83.22 119.44,86.37 119.26,86.55 ; v1(81.43,85.08) 80.82,85.69 77.97,85.69 75.95,83.67 73.14,83.67 72.04,82.57 66.11,82.57 65.51,83.16 C84.2 PRT2.2 v1(66.38,84.09) ; 118.62,85.87 119.26,86.51 119.26,86.55 ; v1(16.97,70.15) 16.53,70.59 PRT3.2 16.35,70.39 15.59,69.63 15.59,68.7 15.39,68.5 C87.2 ; 119.26,86.55 v1(119.26,86.63)
GND: length 1463.6
  TOP w0.102: 70.75,30.39 v1(70.77,30.37)
  TOP w0.178: U6.2 164.89,27.57 v1(164.9,27.58) ; v1(167.03,25.19) 166.96,25.12 U6.62 ; U6.5 163.69,27.56 v1(163.7,27.58)
  TOP w0.203: U3.P1 82.62,33.74 83.02,34.14 83.35,34.14 83.74,33.74 U3.T1 ; v1(112.94,60.71) 112.64,61.01 PU7.1 ; PU7.14 108.84,61.41 v1(108.71,61.28) ; v1(108.8,62.86) 109.04,62.61 PU7.11 ; v1(79.61,40.91) 79.23,40.54 79.02,40.54 78.79,40.31 78.79,39.89 78.38,39.48 U3.J8 ; U2.J8 77.99,27.42 77.18,27.42 U2.G8 ; PU7.3 112.83,61.81 v1(112.96,61.94)
  TOP w0.229: v1(76.55,33.18) 76.78,33.41 U3.G1
  TOP w0.254: U3.G9 U3.G8 ; U2.T9 83.98,28.94 v1(83.54,29.38) ; v1(83.58,22.61) 83.98,22.22 U2.T1 ; v1(134.16,84.27) 134.54,83.9 F3J1.8 ; U4.T9 84.09,60.06 84.09,60.62 83.66,61.05 v1(83.6,61.05) 83.46,60.91 83.39,60.91 83.1,60.62 83.1,60.56 82.5,59.95 U4.P9 ; v1(37.7,85.37) 37.7,85.35 37.01,84.66 U14.18 ; v1(37.54,22.95) 37.67,23.08 HR37.1 ; F3J1.3 137.04,84.47 136.73,84.78 136.32,84.78 v1(135.74,85.36) ; U14.25 34.96,82.13 35.21,81.88 U14.10 v1(35.21,80.84) ; U2.M1 80.78,22.11 80.48,21.81 v1(80.48,21.61) ; U16.15 161.95,83.18 v1(161.7,82.92) 161.95,82.68 U16.16 ; U16.12 163.13,84.21 163.3,84.04 163.3,83.25 v1(163.02,82.97) 162.94,83.05 162.94,83.81 162.63,84.12 U16.13 ; U14.21 35.21,86.9 34.81,87.3 v1(34.81,87.66) ; U5.J2 77.99,65.49 v1(77.98,65.49) ; U17.13 158.59,84.77 158.99,85.17 v1(159.48,85.17) 159.5,85.17 159.09,84.76 U17.12 ; HR39.1 31.95,22.6 32.23,22.32 v1(32.46,22.32) ; U3.T1 84.17,33.56 85.82,33.56 v1(86.26,33.11) ; v1(84.53,71.09) 84.14,71.49 U5.T9 ; U2.P1 82.32,22.15 82.31,22.15 82.02,21.86 82.02,21.85 81.97,21.8 v1(81.97,21.6) ; v1(84.41,53.13) U4.T1 ; v1(31.32,22.32) 31.01,22.32 30.81,22.52 HR44.2 ; v1(82.27,31.16) 82.18,31.25 82.18,32.4 81.74,32.84 81.74,32.85 80.84,33.74 U3.M1 ; HR40.1 33.1,22.6 33.38,22.32 v1(33.73,22.32) ; U4.J2 78.78,53.96 v1(78.78,53.96) ; U17.16 159.27,82.65 v1(159.54,82.92) 159.31,83.15 U17.15 ; U3.T9 84.13,40.3 v1(85.37,40.3) ; v1(82.76,53.14) 82.75,53.14 82.75,53.15 82.78,53.15 82.78,53.16 U4.P1 ; CON2.29 110.31,85.62 109.58,84.88 v1(109.58,84.38) 109.58,84.19 109.83,83.94 CON2.27 ; U4.M1 80.68,53.46 80.68,52.95 81.13,52.5 v1(81.14,52.5) ; U17.10 160.09,84.62 160.32,84.85 v1(160.32,85.12) ; v1(164.14,80.64) 164.63,81.13 U16.5 ; v1(84.02,78.19) 84.46,77.75 CON5.11 ; U17.5 160.59,80.78 v1(160.86,80.51) ; v1(85.4,78.17) 85.46,78.11 CON5.9 ; v1(81.2,41.29) 80.95,41.29 80.69,41.03 80.69,40.31 80.78,40.21 U3.M9 ; v1(162.51,32.94) 162.14,32.94 R134.1 ; CKRN2.2 39.51,72.18 v1(39.84,72.51) 40.16,72.19 CKRN2.4 ; v1(34.88,22.32) 34.62,22.32 34.24,22.7 HR41.1 ; HR42.1 35.38,23.46 v1(34.88,22.95) ; U3.J2 78.38,34.54 v1(77.98,34.94) ; v1(78.78,71.09) 78.78,71.09 U5.J8 ; v1(24.08,82.11) 24.33,82.36 U13.10 ; v1(22.23,83.18) U13.6 ; v1(24.33,87.77) U13.21 24.33,85.29 U13.25 ; v1(33,81.61) 33.11,81.73 U14.6 ; U4.B1 72.79,53.55 73.18,53.94 v1(73.18,53.94) ; U16.10 164.13,83.17 v1(163.88,82.92)
  TOP w0.279: XDP1.32 74.78,8.37 v1(74.75,8.35) ; U19.12 158.38,56.04 v1(158.45,55.97) ; v1(176.73,48.87) U21.3 U21.21 U21.13 v1(176.73,54.02) ; U19.5 155.12,53.59 v1(155.27,53.43) ; XDP1.1 67.28,5.57 v1(67.51,5.81) ; XDP1.26 73.28,11.76 v1(73.18,11.85) ; XDP1.8 68.78,11.59 v1(69.04,11.85) ; U19.16 155.89,57.39 155.78,57.5 v1(155.78,57.66) ; v1(70.28,11.85) XDP1.14 ; XDP1.50 79.28,8.81 v1(78.82,8.35) ; v1(26.35,86.8) 26.35,86.44 26.2,86.29 U13.18 ; XDP1.7 68.78,0.87 ; XDP1.13 70.28,0.89 ; U19.13 158.38,56.54 v1(158.45,56.61) ; XDP1.37 76.28,5.3 v1(75.77,5.81) ; 79.28,0.93 XDP1.49 ; CON2.28 96.23,83.21 v1(95.8,83.21) ; v1(67.26,12.03) 67.28,12.02 XDP1.2 ; XDP1.20 v1(71.78,11.85) ; XDP1.31 74.78,0.88 ; v1(76.28,8.35) 76.28,8.35 XDP1.38 ; v1(158.48,55.04) U19.10 ; XDP1.19 71.78,0.89 ; 81.78,0.84 XDP1.59 ; XDP1.25 73.28,5.71 v1(73.18,5.81)
  TOP w0.305: U3.D1 74.38,33.52 74.73,33.17 v1(74.76,33.17) 74.88,33.29 74.88,33.44 U3.E1 ; U5.G9 76.78,71.53 v1(76.4,71.9) 75.99,71.49 U5.F9 U5.G8 ; U2.B9 72.78,28.67 v1(73.15,29.05) ; v1(81.18,71.89) U5.M9 ; U3.P9 82.26,40.26 82.26,40.89 82.73,41.36 v1(82.78,41.36) ; v1(74.79,38.94) 75.18,39.33 U3.E8 ; v1(74.79,38.94) U3.E7 ; v1(74.79,38.94) U3.D8 ; v1(73.33,50.56) 73.33,50.71 74.76,52.14 75.37,52.14 76.78,53.55 U4.G1 ; U5.M1 80.78,65.06 v1(81.23,64.61) ; v1(82.78,71.09) 82.39,71.49 U5.P9 ; U4.M9 80.78,60.06 80.67,60.17 v1(80.42,60.42) ; U2.A9 71.59,29 v1(71.1,29) ; v1(74.63,26.51) 74.68,26.51 U2.E7 U2.D8 ; U4.D3 74.38,56.39 75.06,57.07 v1(75.72,57.07) 75.18,57.6 U4.E7 ; v1(72.34,55.62) 72.78,55.18 U4.B3 ; U3.G9 76.78,40.25 77.98,41.44 v1(78.08,41.44) ; v1(75.64,64.56) 75.18,65.02 U5.E1 ; v1(72.42,64.23) 72.42,64.72 U5.B1 ; U4.B9 72.63,60.11 72.63,60.22 72.39,60.46 v1(72.39,60.62) ; v1(77.22,21.73) 77.22,21.77 U2.G1 ; v1(73.18,23.41) 72.78,23.8 U2.B3 ; U4.D8 74.38,59.16 v1(74.78,59.55) 75.18,59.15 U4.E8 ; v1(75.57,29.07) 75.98,28.66 U2.F9 75.98,28.61 v1(75.58,28.21) 75.18,27.81 U2.E8 ; v1(72.18,67.29) U5.B3 ; v1(72.39,21.81) 72.78,22.2 U2.B1 ; U3.F9 75.98,40.5 v1(75.74,40.73) ; U3.B1 72.78,33.73 v1(72.19,33.14) ; v1(77.98,58.76) 77.98,58.77 77.99,58.76 U4.J8 ; U5.G1 76.78,64.73 v1(76.58,64.53) ; U2.G8 76.66,27.93 76.66,28.49 U2.G9 76.78,28.62 v1(76.3,29.1) ; v1(73.99,53.13) 74.38,53.52 U4.D1 U4.E1 U4.E2 ; U3.A9 71.98,40.22 v1(72.34,40.58) 72.78,40.14 U3.B9 ; v1(74.38,24.46) U2.D3 ; U3.B3 71.99,36.14 v1(71.99,36.58) ; v1(70.74,59.71) 71.2,60.17 71.66,60.17 71.87,59.95 U4.A9 ; U5.E8 v1(74.78,71.09) 74.38,70.69 U5.D8 U5.E7 ; U2.P9 82.38,29.11 v1(82.27,29.22) 81.39,29.22 U2.M9 ; U5.A9 U5.B9 72.78,71.89 v1(72.49,72.18) ; U2.D1 74.49,22.1 74.49,21.9 v1(74.75,21.63) 75.18,22.06 U2.E1 U2.E2 ; U5.T1 83.54,64.64 82.89,64.64 v1(82.81,64.56) 82.38,64.99 U5.P1 ; v1(75.62,35.88) 74.92,35.88 U3.D3 U3.E2 ; U5.E2 U5.D1 74.07,64.77 74.07,64.42 v1(73.64,63.99) ; U4.F9 75.64,60.29 75.64,61.1 v1(76.18,61.64) 76.78,61.03 U4.G9 76.78,59.68 76.63,59.53 76.63,59.3 U4.G8 ; v1(74.02,67.51) 74.02,67.05 U5.D3 ; HU1.3 v1(64.74,71.76) ; v1(77.98,23.41) 78.38,23.01 U2.J2
  TOP w0.356: U9.9 126.97,40.78 v1(126.67,40.48) ; Q30.4 170.89,70.11 v1(171.36,69.64) ; U9.18 v1(125.67,34.36) ; v1(127.56,42.84) 127.62,42.78 U9.8 127.62,40.43 v1(127.27,40.07) ; PQ31.1 131.77,18.47 v1(131.65,18.58) ; v1(126.26,59.2) 126.61,58.85 PQ32.1 ; U9.4 130.22,43.54 CB5.2 130.87,43.31 U9.3 ; v1(132.79,40.4) 131.99,40.4 131.52,40.86 131.52,41.7 ; U9.25 v1(130.22,34.28) ; U9.11 125.67,39.89 v1(125.72,39.84) ; PC4.2 26.54,60.72 27.1,60.16 v1(27.26,60.16) ; U9.1 132.17,42.81 133.02,43.65 v1(133.12,43.65) ; v1(72.76,81.6) 72.98,81.6 73.24,81.33 U12.5
  TOP w0.381: v1(93.79,71.03) 93.41,71.41 R223.2 ; v1(26.49,72.99) 26.38,73.11 26.38,73.11 26.33,73.17 26.33,73.41 26.06,73.69 SR9209.1 ; v1(158.35,60.44) 158.14,60.65 Q9200.1
  TOP w0.406: CA11.2 160.95,52.97 v1(160.58,52.6) ; v1(94.12,86.43) 94.12,86.66 94.47,87.01 95.05,87.01 95.33,86.74 CON2.30 ; UA3.13 160.81,54.45 v1(160.35,53.98) ; Q30.1 169.59,67.5 v1(169.5,67.4) ; Q31.1 174.29,71.32 174.58,71.04 v1(174.83,71.04) ; R37.2 87.68,71.9 88.01,71.57 ; UA3.8 v1(161.15,58.62) ; 87.81,70.81 R33.2 ; v1(159.58,57.09) 159.61,57.12 UA3.9 ; UA3.12 159.61,55.17 v1(159.58,55.14) ; UA3.11 159.61,55.82 v1(159.58,55.79) ; v1(139.73,38.26) 140.15,38.68 PQ10.4 ; v1(159.58,56.44) 159.61,56.47 UA3.10 ; Q29.4 173.81,66.46 v1(173.56,66.21) ; v1(173.81,69.56) 173.73,69.65 Q27.4 ; v1(172.51,65.98) Q29.1 ; Q31.4 175.59,74.41 v1(175.77,74.59) ; v1(155.62,62.78) Q9200.4 ; v1(171.02,67.4) 171.81,67.4 172.43,68.03 Q27.1 ; v1(137.79,41.53) 137.62,41.37 PC52.2 137.62,40.21 137.48,40.07 PQ9.4 ; PQ9.1 136.18,38.1 v1(136.08,38.21) ; PQ10.1 v1(138.85,38.26)
  TOP w0.432: C57.2 v1(157.32,19.79) ; CB6.2 128.04,43.32 v1(127.56,42.84) ; v1(161.82,15.44) 161.82,15.66 161.49,16 C9214.2 ; v1(156.72,17.21) 156.82,17.31 C9207.2 ; C68.2 159.96,15.54 160.12,15.54 160.48,15.18 v1(160.48,15.13) ; v1(154.66,19.04) 155.46,19.84 C58.2
  TOP w0.457: PC19.2 24.61,60.23 v1(24.85,59.98) 24.85,60.74 24.77,60.82 PC37.2 ; C199.2 v1(181.89,49.24) ; v1(22.81,72.91) 22.49,72.59 SR86.2 ; v1(167.3,80.43) 167.29,80.43 167.37,80.36 168.37,80.36 C163.2 ; CA10.2 v1(164.98,53.48) ; C194.2 156.26,77.16 156.59,76.83 156.59,75.56 v1(156.59,75.56) ; R382.2 172.51,53.05 v1(171.53,53.05) ; C88.2 105.45,70.57 105.77,70.25 v1(105.77,69.89) ; PR148.2 124.12,58.59 v1(124.49,58.59) ; C85.1 77.58,85.75 78.21,85.12 78.3,85.12 78.32,85.09 v1(78.32,85.07) ; PC141.2 118.86,57.95 v1(118.75,58.06) ; v1(34.16,61.02) 34.64,61.5 34.64,62.36 PC30.2 ; PR207.2 v1(126.9,18.75) ; v1(125.3,56.27) 125.23,56.34 PC128.2 ; C165.2 163.39,86.98 v1(163.39,87.39) ; R98.2 16.67,74.58 16.49,74.77 v1(16.44,74.77) 16.05,74.77 15.84,74.55 R97.2 ; v1(182.04,52.34) 181.61,51.91 R389.2 ; CB5.2 v1(130.43,44.53) ; v1(115.37,61.36) 115.3,61.42 PC159.2 ; v1(27.01,57.16) 26.54,56.69 PC34.2 ; PC172.2 v1(120.5,18.09) ; PC155.2 116.11,64.89 v1(116.11,65.49) ; PR72.2 140.6,36.51 140.6,36.61 v1(140.92,36.92) ; R338.2 39.54,84.14 39.65,84.26 v1(39.65,84.53) 39.65,85.09 R337.2 ; v1(171.53,51.02) 172.51,51.02 R384.2 ; CB2.2 124.75,43.65 123.98,44.42 v1(123.98,44.86) ; v1(163.78,36.92) 163.82,36.89 R346.2 ; CB4.2 v1(129.95,30.57) ; CR5.2 116.12,77.17 115.15,76.19 SC6.2 115.15,75.25 v1(115.11,75.21) ; PC18.2 33.62,66.8 v1(34.1,66.8) 34.05,66.85 SC1.2 ; SC2.2 94.1,80.42 v1(93.8,80.71) 96.01,80.71 C79.2 ; v1(118.58,58.78) PR159.2 ; PC33.2 27.31,59.56 v1(27.31,59.56) 26.98,59.56 26.52,59.1 PC23.2 ; CB3.2 v1(125.78,30.57) ; v1(28.25,86.77) 28.25,86.31 28.75,85.81 28.75,85.38 R329.2 R330.2 ; MC1.1 39.61,81.68 40.04,81.25 v1(40.04,81.2) 39.7,80.86 MC2.1 ; v1(179.02,78.96) 179.24,78.74 C178.2 ; R127.1 170.21,25.61 170.21,26.08 v1(170.26,26.13) ; C70.2 113.53,78.06 v1(113.41,77.94) ; v1(171.53,51.66) 172.38,51.66 R385.2 ; v1(171.52,49.42) 171.67,49.57 172.33,49.57 R383.2 ; v1(136.82,42.46) 137.08,42.2 PR71.2 ; v1(88.95,58.67) 88.77,58.67 88.34,59.1 D3CE24.2 ; v1(169.04,85.49) 169.52,85.01 C182.2 ; v1(139.48,41.09) 139.09,40.71 139.09,40.49 PC54.2 ; C51.2 50.24,70.65 v1(50.67,71.09) ; C431.2 7.75,77.82 7.28,77.35 C176.2 6.95,75.84 v1(6.4,75.84) ; PC71.2 140.66,57.97 v1(140.06,57.97) ; v1(124.92,30.57) CB1.2 ; v1(181.88,51.02) R388.2 ; C146.2 v1(174.9,33.81) ; v1(19.38,81.01) 19.47,81.01 R327.2 R328.2 ; v1(28.83,73.51) 28.73,73.41 R401.2 ; v1(31.63,72.09) 31.6,72.12 R85.2 ; PR212.2 v1(131.51,55.28) ; v1(85.45,23.36) 86.01,22.8 C1.2 ; v1(110.7,67.1) PC151.2 111.13,66.44 111.15,66.41 PC149.1 ; v1(115.47,65.49) 115.47,65.24 115.13,64.9 PR174.2 ; C144.2 v1(168.87,38.94) ; v1(163.37,16.6) 163.46,16.52 C54.2 ; v1(5.28,80.71) 6.08,81.51 C9220.2 ; v1(181.87,50.13) C200.2 ; PC36.2 28.12,55.98 v1(28.35,55.74)
  TOP w0.508: Q10.2 116.46,70.02 v1(116.41,69.97) ; C16.2 69.15,20.43 v1(69.78,19.8) ; v1(128.47,79.34) 128.32,79.5 Q8.2 ; R63.1 56.41,21.04 v1(56.44,21.07) ; v1(169.42,31.51) 169.42,31.52 169.2,31.74 Q23.2 ; D3CE8.2 69.81,49.58 C31.2 69.89,48.74 v1(69.89,47.96) 69.89,47.07 70.3,46.66 C28.2 ; C130.2 154.37,13.37 v1(154.99,13.99) ; R291.2 v1(172.06,16.36) ; C143.2 146.87,7.98 v1(146.89,7.97) ; C1195.2 59.32,14.51 v1(59.26,14.44) ; CON5.13 v1(89.98,78.56) ; v1(108.05,59.02) 107.83,59.02 107.58,59.27 PR175.2 ; v1(157.91,38.27) 157.91,39.22 D18.1 ; C33.2 v1(69.23,34.82) ; v1(12.13,22.87) 12.14,22.87 12.42,22.59 PC85.2 ; H1.1 42.95,23.5 GR3.2 HR9.2 ; C1187.2 73.65,50.23 v1(73.33,50.56) ; v1(120.85,30.98) 120.85,31.35 R440.2 ; D3CE26.2 69.64,53.24 v1(70.13,53.74) ; v1(34.16,59.95) 34.71,59.4 PC25.1 ; v1(69.11,31.92) 68.95,32.08 C19.2 ; v1(121.36,77.97) 121.02,77.97 CR6.2 ; PC119.2 122.26,58.74 v1(121.59,58.74) ; v1(154.64,82.39) 154.71,82.46 SW1.5 ; v5(45.37,61) 45.29,60.93 44.63,60.93 44.21,60.51 v1(44.21,59.2) ; R72.2 55.68,68.85 v1(55.93,69.11) 56.02,69.19 PC31.2 ; C1175.2 55.68,56.68 55.73,56.74 C1174.2 56.72,57.32 v1(57.02,57.62) ; PC157.2 PC158.2 113.81,58.9 v1(113.68,59.03) ; R35.2 R31.2 81.57,44.56 82.04,44.09 82.04,42.61 v1(82.37,42.28) ; PC26.2 35.23,54.87 35.14,54.78 HC6.2 34.56,54.46 v1(34.93,54.09) ; C116.2 21.07,64.39 v1(21.07,65.38) ; GC1.2 78.44,14.19 v1(78.56,14.32) ; C34.2 70.48,30.66 70.75,30.39 ; v1(29.07,61.32) 29.08,61.32 PC3.2 ; D3CE20.2 87.17,20.54 v1(87.73,19.98) ; R34.2 87.33,30.45 87.85,29.93 v1(88.34,29.93) ; PC17.2 33.15,73.14 v1(33.15,73.52) ; Q12.2 112.09,70.11 v1(111.96,69.99) ; AC3.2 51.31,55.82 v1(51.79,55.34) ; C23.2 60.71,82.5 61.02,82.81 D3CE40.2 61.46,82.81 62.31,81.96 62.31,81.7 v1(62.51,81.5) ; C9215.2 v1(158.66,15.16) ; C29.2 87.87,55.18 88.7,56 v1(89.16,56) ; R99.2 14.7,73.05 v1(14.37,73.39) ; C70.2 113.53,79.35 113.96,79.79 Q9.2 ; v1(169.65,27.55) 169.14,27.04 169.14,27.04 C67.2 ; C30.2 65.84,61.71 65.05,62.5 65.05,62.74 v1(65.04,62.76) ; R62.1 57,14.44 v1(57.79,14.44) ; v1(159.23,32.45) 159.24,32.44 V1C21.2 ; D3C7.2 70.04,26.69 v1(70.69,26.69) 70.69,26.84 69.93,27.6 C35.2 ; v1(164.54,39.08) 164.52,39.06 Q37.2 ; CKC7.2 36.33,74.86 36.72,75.25 v1(36.72,75.6) ; v1(54.54,17.9) 54.54,17.16 R60.1 ; U6.65 v1(159.66,22.92) ; U6.65 v1(162.29,20.3) ; U6.65 v1(162.29,25.61) ; v1(155.86,29.46) 155.86,29.71 156.17,30.03 R60358.1 ; v1(181.89,53.23) 181.45,53.23 R377.2 ; C142.2 147.97,8.04 v1(148.03,7.97) ; v1(44.7,78.53) 44.41,78.82 SR70.1 ; v1(79.4,18.58) 79.12,18.86 R44.1 ; GR2.2 22.59,24.67 v1(21.97,25.29) ; PC12.2 18.49,56.23 v1(18.19,55.92) ; v1(124.77,79.34) 124.74,79.37 Q14.2 ; C162.2 171.05,80.31 170.44,79.7 v1(170.18,79.7) ; 13.23,75.58 v1(13.23,75.51) ; 13.23,75.58 13.69,76.04 R60365.2 ; 13.23,75.58 13.23,75.63 12.85,76.01 R60364.2 ; F3CB4.2 133.3,81.75 132.62,82.43 v1(132.62,83.07) ; PC220.2 29.09,62.68 29.35,62.68 v1(30.16,63.48) ; HR8.2 HR7.2 v1(45.59,22.37) ; C1190.2 48.97,21.09 48.97,22.04 49.35,22.42 50.17,22.42 v1(50.21,22.39) 50.21,21.84 50.56,21.48 R47.1 ; GC2.2 v1(81.2,14.32) ; C201.2 29.54,20.73 29.54,19.52 29.29,19.27 v1(28.75,19.27) ; R108.2 44.05,61.69 v1(44.17,61.56) 44.65,62.04 44.98,62.04 ; PC74.2 12.11,16.33 v1(11.84,16.59) ; C25.2 86.79,54.98 v1(86.23,55.54) ; v1(44.57,76.63) 44.84,76.36 45.82,76.36 PC6.2 ; v1(58.62,14.44) 58.62,14.65 57.99,15.28 C1194.2 ; v1(112.07,56.75) 112.07,57.01 112.53,57.48 PC156.2 ; v1(88.11,33.27) 88.27,33.11 D3CE23.2 ; PC20.2 32.91,58.41 33.2,58.12 v1(33.73,58.12) ; CA13.2 v1(164.16,59.99) ; v1(154.64,80.46) 154.89,80.21 SW1.4 ; v1(52.4,66.41) 52.58,66.59 C52.2 ; C4.2 88.26,38.79 v1(88.27,38.78) ; v1(66.22,57.57) 66.22,57.53 66.74,57.01 D3CE7.2 ; v1(156.44,12.9) 156.21,13.13 C131.2 ; SR89.2 18.42,72.1 18.21,72.31 v1(17.93,72.31) ; v1(10.19,11.78) 10.61,11.35 PC73.2 ; v1(10.54,82.16) 10.66,82.05 C432.2 ; D3CE25.2 68.86,26.28 v1(69.09,26.05) ; v1(155.35,22.45) 155.55,22.65 C9209.2 ; v1(19.91,57.31) 19.91,57.31 PC35.2 ; v1(161.36,30.68) C59.2 ; PC50.2 14.87,50.02 14.7,49.84 v1(14.36,49.84) ; v1(89.13,39.21) 89.33,39.41 C24.2 88.66,40.42 88.65,40.41 D3CE37.2 ; C164.2 157.67,86.44 v1(156.82,87.29) ; R131.1 160.96,32.82 v1(160.96,33.44) ; Q33.2 178.67,66.93 v1(178.13,66.39) ; C9211.2 159.44,30.55 v1(159.23,30.75) ; v1(109.63,77.84) 109.64,77.83 CR8.2 ; C41.2 C14.2 69.03,61.55 v1(69.09,61.49) ; v1(69.95,59.71) 69.95,59.16 C15.2 ; v1(162.2,30.7) C9213.2 ; HR5.1 19.14,26.75 v1(19.18,26.79) ; v1(79.78,18) 80.25,18.47 C1185.2 ; v1(30.35,57.02) 30.42,56.95 PC16.2 ; v1(35.04,73.28) 35.13,73.36 CKC3.2 ; C128.2 149.27,13.21 ; R128.1 170.23,22.79 170.23,22.34 v1(170.21,22.32) ; v1(169.58,22.83) 169.52,22.89 C55.2 ; v1(40.67,57.99) 40.49,58.17 37.96,58.17 PC24.2 ; v1(137.43,35) 137.38,35.05 PC53.2 ; v1(71.99,36.58) 71.12,37.44 C1186.2 ; C1188.2 71.75,18.86 v1(71.64,18.75) ; PC83.2 15.25,12.93 v1(14.53,13.66) 13.82,12.95 PC76.2 ; C60.2 167.29,30.49 v1(166.27,31.51) ; D3CE21.2 68.75,23.54 C36.2 70.36,23.54 v1(70.59,23.77) ; Q22.2 v1(174.45,29.61) ; C9210.2 169.33,25.66 v1(169.34,25.67) ; v1(120.17,79.34) 118.57,79.34 118.09,79.82 Q13.2 ; C9200.2 154.31,66.87 v1(154.38,66.95) ; HC1.2 68.98,68.53 69.08,68.62 v1(69.09,68.62) ; C129.2 150.36,13.34 ; Q11.2 121.43,79.43 v1(121.52,79.34) ; S1R5.2 v1(160.83,47.91) ; C156.2 v1(159.27,36.86) ; PC10.2 56.5,76.02 PC8.2 56.5,77.13 PC9.2 56.5,78.49 56.66,78.64 56.66,79.4 v1(56.44,79.62) ; AC2.2 50.82,58.21 v1(51.51,58.89) 51.51,60.39 ; v1(62.03,79.28) 62.02,79.27 D3CE41.2 60.41,79.27 D3CE39.2 ; HR12.2 66.92,70.85 66.4,71.36 v1(66.22,71.36) ; R46.1 78.03,16.71 79.1,17.77 v1(79.1,17.97) ; v1(172.16,73.75) 172.13,73.79 Q28.2 ; C9206.2 155.03,16.86 v1(154.59,16.86) ; C26.2 91.22,53.38 C27.2 90.17,54.53 v1(90.07,54.63) ; v1(178.03,73.65) 177.77,73.39 Q32.2 ; R217.2 98.49,78.69 97.89,78.09 v1(97.47,78.09) ; v1(46.56,15.97) 46.48,16.05 C1191.2 ; PC38.2 32.45,61.34 v1(32.21,61.1) 31.87,60.76 SR9210.1 ; v1(170.97,26.13) 171.05,26.21 R132.1 ; v1(90.73,61.59) 90.8,61.51 R36.2 ; PR186.2 v1(118.11,16.06) ; 36.76,22.09 36.78,22.12 36.78,23.4 HR38.1 ; v1(116.54,79.34) 115.44,79.34 115.01,79.77 C82.2 ; C1184.2 75.18,18.88 v1(74.86,19.2) ; C22.2 85.48,40.41 v1(85.37,40.3) ; v1(72.34,40.58) 71.99,40.93 C13.2 ; C1176.2 59.97,57.75 60.67,57.05 v1(60.88,57.05) ; v1(155.22,59.28) 154.92,58.97 C171.2 ; v1(50.24,15.97) 49.35,15.97 R45.1 C1189.2 ; v1(171.81,54.42) 172.26,53.97 C198.2 ; v1(88.34,29.29) 87.23,29.29 R30.2 ; v1(89.16,55.31) 88.94,55.09 D3CE36.2 ; R289.2 v1(174.21,17.11) ; Q39.2 v1(131.45,16.66) ; v1(57.08,21.07) 57.08,20.54 56.84,20.31 C1193.2 ; C39.2 68.99,65.65 v1(69.08,65.56) 69.08,65.5 69.03,65.45 C11.2 ; v1(124.49,58.59) 124.77,58.87 PR149.1 ; v1(62.69,78.03) 62.69,77.84 62.13,77.28 60.91,77.28 60.68,77.52 D3C8.2 59.99,77.53 D3C5.2 ; R61.1 54.64,18.69 55.32,18.01 v1(55.32,17.9) ; v1(57.71,21.07) 57.71,20.31 C1192.2 ; C32.2 D3CE24.2 ; C56.2 v1(168.28,27.84) ; HR13.2 62.36,67.05 62.28,67.12 v1(62.28,67.84) ; v1(86.41,18.64) 86.96,19.18 C17.2 ; PC51.2 18.56,50.71 19.51,51.66 20.08,51.66 v1(20.32,51.41) ; R32.2 90.18,57.64 v1(90.07,57.52) ; PC170.2 v1(119.48,15.84) ; SR21.2 23.56,72.45 23.7,72.59 23.7,72.99 v1(23.72,73.01) ; C9212.2 v1(169.65,21.85) ; v1(158.19,66.77) 158.17,66.79 R371.1
  IN1 w0.508: v1(163.7,27.58) v1(164.9,27.58) 164.9,25.85 165.56,25.19 v1(167.03,25.19)
  BOTTOM w0.102: U1.AP10 39.41,61.97 39.63,61.97 40.02,61.58 U1.AR11 ; U1.AT61 39.88,31.07 39.88,31.25 39.7,31.43 39.45,31.43 39.38,31.36 38.99,31.36 U1.AN60
  BOTTOM w0.127: v1(39.48,65.36) 39.34,65.5 39.34,66.16 U1.AP3 ; v1(23.61,66.8) 23.58,66.84 23.08,66.84 22.77,67.15 U1.D2 22.59,66.96 22.87,66.68 22.87,65.94 v1(22.55,65.63)
  BOTTOM w0.152: U1.G5 24.43,65.64 24.37,65.7 24.37,66.17 U1.G3 ; U1.AY22 44.72,54.84 v1(45.04,54.53) ; v1(44.04,49.75) 44,49.71 U1.AY30 ; U1.V58 30.31,32.2 30.31,30.81 U1.U61 ; U1.AN63 38.9,28.49 v1(38.97,28.42) ; U1.AY26 43.75,52.14 43.76,52.14 44.49,52.14 v1(44.66,51.97) ; U1.AT13 40.61,60.3 41.51,60.3 U1.AV14 ; v1(44.45,37.52) 44.21,37.52 43.51,36.82 U1.AY51 ; v1(36.56,28.31) 36.47,28.41 U1.AJ63 ; U1.AU57 40.77,32.95 40.77,32.4 40.87,32.3 U1.AU59 ; v1(43.99,33.11) 43.93,33.04 U1.AY57 ; v1(44.3,35.5) 44.28,35.47 U1.AY53 ; U1.AY24 43.77,53.49 43.78,53.5 v1(43.87,53.5) ; U1.AY18 42.87,57.22 43.89,57.22 v1(44.03,57.36) ; U1.AW16 42.2,58.62 U1.AY16 42.88,58.68 42.89,58.68 43.45,58.68 43.98,59.2 v1(44.21,59.2)
  BOTTOM w0.178: U10.113 106.58,74.92 105.49,76.01 v1(105.49,76.65) ; U10.49 106.98,91 ; U1.AN60 38.49,31.45 38.47,31.47 38.19,31.47 38.17,31.45 U1.AL60 37.21,31.45 37.2,31.47 36.83,31.47 36.81,31.45 U1.AJ60 36.11,31.45 v1(35.93,31.63) ; U10.91 113.62,77.73 v1(113.41,77.94) ; U10.1 98.12,75.73 97.84,75.45 v1(97.84,74.49) ; U1.AU53 40.87,35.06 40.85,35.05 40.85,34.76 40.87,34.74 U1.AU55 U1.AV55 ; v1(39.71,52.91) 39.98,52.91 40.34,52.54 40.35,52.54 40.4,52.49 40.51,52.49 U1.AU26 ; v1(97.65,86.15) 97.66,86.13 U10.27 ; U1.AY24 U1.AW24 U1.AV24 U1.AU24 ; U1.AU20 40.94,55.98 40.94,55.64 40.85,55.55 40.85,55.27 40.87,55.25 U1.AU22 ; U1.AV16 U1.AU16 U1.AR17 U1.AP17 U1.AN17 U1.AM17 U1.AL17 ; U1.AL57 37.43,33.34 37.01,33.76 v1(37.01,33.77) ; v1(103.27,72.85) 102.98,73.13 U10.122
  BOTTOM w0.203: U1.AU30 40.8,49.77 39.93,49.77 U1.AR31 ; v1(41.38,68.7) 41.17,68.49 U1.AU1 ; U1.AJ13 36.94,60.23 U1.AL13 36.96,59.9 36.83,59.9 U1.AJ14 ; v1(44.15,68.9) 44.15,66.65 43.38,65.88 U1.AY4 42.62,65.88 42.57,65.83 U1.AW4 ; U1.U22 29.97,54.12 30.6,53.5 v1(30.63,53.5) ; 4.99,31.61 4.43,31.61 4.19,31.84 PU5.3 ; U1.D59 22.6,32.04 22.89,32.04 23,32.15 23.46,32.15 23.64,32.33 U1.F58 ; v1(16.63,19.07) 16.6,19.09 PU4.19 ; U1.AY33 42.84,48.33 43.65,48.33 43.78,48.19 v1(43.84,48.19) ; v1(29.16,54.12) U1.R22 ; U1.AT43 40.84,41.17 40.84,41.8 40.28,42.35 v1(40.28,42.35) ; v1(43.96,64.55) 43.84,64.43 U1.AY6 ; v1(32.59,54.06) 32.41,54.23 U1.AB22 ; U1.N21 27.53,55.71 U1.M22 ; PU4.29 13.83,15.87 v1(13.86,15.84) ; v1(39.06,32.85) 39.06,33.1 39.25,33.3 U1.AP57
  BOTTOM w0.254: v1(20.07,46.3) 20.1,46.26 U1.A36 U1.B36 ; v1(40.67,57.99) 40.67,57.86 40.87,57.66 U1.AU18 40.87,57 40.81,56.95 40.81,56.43 40.87,56.37 U1.AU20 U1.AV20 ; U1.AY59 43.43,31.72 44.17,30.97 v1(44.69,30.97) ; D21.2 126.9,71.15 C159.2 ; v1(20.33,43.67) 20.42,43.75 U1.A40 U1.B40 v1(22,43.75) ; P2.33 163.75,10.16 v1(163.65,10.25) ; U1.AT42 40.57,42.64 v1(40.28,42.35) 40.03,42.1 U1.AR43 ; v1(155.58,8.3) 155.25,8.62 P2.16 v1(155.25,10.53) ; v1(159.72,10.25) 159.75,10.22 P2.25 ; U1.L61 26.65,30.81 26.58,30.81 v1(26.57,30.81) ; v1(40.49,44.7) 39.86,44.7 U1.AP38 ; v1(40.49,44.7) 40.73,44.94 U1.AT37 ; v1(40.49,44.7) 40.73,44.45 U1.AT40 ; v1(38.43,45.74) 38.47,45.74 38.73,46 U1.AN36 38.97,46.46 38.97,46.84 U1.AN35 ; v1(40.64,51.43) 40.87,51.2 U1.AU28 U1.AV28 ; U1.A24 U1.B24 21.58,53.69 21.98,53.69 ; U1.D8 22.63,63.65 22.77,63.79 v1(22.85,63.79) ; CON10.45 2.77,82.24 2.42,81.89 v1(2.32,81.89) ; U1.AM1 38.22,68.32 v1(38.32,68.41) ; v1(21.98,33.56) 21.65,33.56 U1.B56 21.34,33.57 20.99,33.57 U1.A56 ; v1(21.98,33.56) 21.81,33.4 U1.C57 U1.D57 ; v1(21.98,33.56) 21.98,33.93 U1.D55 22.46,34.65 U1.D54 ; v1(161.16,10.15) 161.25,10.07 P2.28 ; U1.D12 22.09,61.07 U1.C11 ; U1.D12 22.3,61.21 22.49,61.39 U1.E11 ; U1.D12 22.3,61.04 22.22,60.97 22.22,60.53 22.3,60.46 U1.D14 22.12,60.28 U1.C14 21.69,59.89 20.97,59.89 20.85,59.77 U1.A14 19.9,59.77 v1(19.86,59.73) ; U1.AU53 40.57,35.77 40.48,35.77 U1.AR52 ; U1.AE58 35.12,31.76 U1.AG60 U1.AG61 U1.AG62 U1.AG63 35.03,29.41 35.03,28.6 v1(35.02,28.59) ; v1(156.68,10.38) 156.68,10.01 156.75,9.94 P2.19 ; U1.AJ58 35.8,32.75 U1.AH57 ; U1.AM52 37.75,36.55 v1(37.75,36.61) 37.75,36.72 U1.AL51 ; v1(29.24,33) U1.T58 29.13,32.43 U1.P59 ; U1.AL31 37.1,50.05 v1(37.08,50.07) 37.43,50.42 U1.AL29 ; U1.AW40 42.16,44.14 v1(42.16,44.21) 41.84,44.53 U1.AV39 ; v1(31.49,68.71) 31.49,68.7 32.23,67.97 U1.AA1 ; U1.C38 21.81,44.68 U1.C39 ; U1.C38 U1.D38 U1.F38 v1(24.23,45.01) ; U1.C38 22.14,44.77 U1.D39 22,43.98 v1(22,43.75) ; U1.C38 22.14,45.24 U1.D37 22.16,45.88 22.16,46.64 U1.D35 22.46,47.19 U1.D34 ; U1.AK3 36.97,66.78 37.07,66.78 v1(37.1,66.81) ; U1.AF11 34.16,61.11 v1(34.16,61.02) 34.25,60.93 U1.AF12 ; U1.AF11 34.47,62.07 U1.AE10 ; U1.AF11 35.2,61.34 U1.AG11 ; U1.D26 22.79,52.77 U1.D25 U1.C25 21.98,53.26 21.98,53.69 ; U1.D26 22.79,52.29 U1.D27 U1.C27 ; U1.D26 U1.F26 v1(24.21,52.53) ; CONSATA.57 96.98,18.33 v1(97.46,17.85) ; U1.AW47 42.17,39.4 v1(42.17,39.5) 42.17,39.58 U1.AV46 ; U1.J63 25.47,29.15 25.47,28.59 v1(25.43,28.54) ; U1.AV36 41.95,46.21 42.33,45.83 42.78,45.83 v1(42.8,45.8) 42.8,45.69 U1.AW37 ; v1(21.99,48.6) 21.66,48.6 U1.B32 U1.A32 ; v1(21.99,48.6) 22.46,48.13 U1.D33 22.46,47.84 U1.D34 ; v1(21.99,48.6) 21.99,48.98 U1.D31 22.79,49.78 U1.D30 ; v1(24.85,59.98) 24.85,60.21 U1.H13 ; v1(39.48,65.36) 39.6,65.25 39.6,65.2 U1.AR5 ; v1(31.84,32.98) U1.AA58 ; U1.V7 30.66,63.87 30.28,63.48 v1(30.16,63.48) ; U1.D30 22.79,50.26 U1.D29 21.99,51.06 v1(21.99,51.11) ; U1.D30 U1.F30 v1(24.21,50.02) ; v1(35.51,33.77) 35.8,34.07 U1.AH55 ; v1(22,38.74) 22,38.51 U1.D49 22.46,37.81 U1.D50 ; v1(22,38.74) 22,38.87 22.46,39.34 U1.D47 22.46,39.67 U1.D46 ; v1(22,38.74) U1.B48 21.41,38.66 20.91,38.66 U1.A48 20.6,38.5 20.14,38.5 v1(20.14,38.5) ; v1(22,41.24) 22,41.47 U1.D43 22.46,42.17 U1.D42 ; v1(22,41.24) 21.98,41.24 U1.B44 U1.A44 20.29,41.24 20.09,41.05 v1(19.74,41.05) ; v1(22,41.24) 22,41.02 22.46,40.56 U1.D45 22.46,40.32 U1.D46 ; U1.K1 26.24,68.42 v1(26.13,68.53) ; P2.31 162.75,9.98 v1(163.02,10.25) 163.02,10.1 163.25,9.87 P2.32 ; v1(2.36,80.6) 2.5,80.74 CON10.48 ; v1(39.06,38.55) 39.38,38.87 U1.AP48 ; v1(39.06,38.55) 39.06,38.37 U1.AN49 ; v1(39.06,38.55) 39.06,38.62 U1.AN48 ; 39.62,54.51 39.79,54.51 U1.AR23 40.82,53.49 U1.AU24 40.87,53.95 40.81,54 40.81,54.32 40.93,54.44 40.93,54.77 U1.AU22 ; 39.62,54.51 39.62,54.86 U1.AP22 ; 39.62,54.51 U1.AP23 ; v1(34.1,66.8) 33.99,66.8 U1.AD3 ; U1.AN46 39.09,40.36 v1(39.09,40.51) 39.09,40.57 U1.AN45 ; U1.AP26 39.71,52.67 v1(39.71,52.91) ; P2.34 164.25,10.21 v1(164.29,10.25) ; U1.B4 21.16,65.54 21.06,65.43 21.06,65.39 v1(21.07,65.38) ; U1.N21 27.98,56.12 v1(28.35,55.74) 28.35,55.74 U1.P22 ; R212.2 93.91,73.31 v1(93.91,72.38) ; v1(22.55,65.63) 22.36,65.43 U1.D5 ; U1.V3 31,66.81 v1(31.11,66.81) ; U1.AW51 U1.AV51 U1.AU51 40.8,36.82 40.49,36.51 v1(40.46,36.51) 40.32,36.51 U1.AR52 ; v1(34.93,54.09) 34.93,54.36 U1.AG23 35.46,54.69 35.66,54.89 U1.AH22 35.64,55.22 U1.AG21 35.64,56.11 U1.AH20 ; v1(30.63,54.14) 30.38,54.4 U1.V23 30.78,55.1 U1.W22 ; U1.AN43 38.41,42.23 v1(38.41,42.3) 38.41,42.5 38.73,42.83 U1.AN42 38.41,43.18 38.41,43.26 v1(38.4,43.28) 38.41,43.29 38.41,43.36 U1.AN40 38.41,44 U1.AN39 38.51,44.16 38.96,44.16 U1.AP39 39.14,44.18 39.62,44.18 U1.AR39 ; U1.AJ14 36.81,59.71 37.17,59.36 37.17,59.31 v1(37.26,59.21) 37.13,59.09 37.13,58.94 37.1,58.91 U1.AL17 ; 26.41,63.61 26.17,63.37 26.17,63.18 25.93,62.94 25.93,62.55 U1.J10 ; 26.41,63.61 v1(26.4,63.61) ; 26.41,63.61 26.49,63.69 26.59,63.69 26.62,63.72 26.7,63.72 U1.L7 ; U1.AF18 34.31,57.68 v1(34.25,57.74) 34.25,57.95 U1.AF17 ; v1(22,43.75) 22,43.53 U1.D41 22.46,42.82 U1.D42 ; U1.F61 23.99,30.47 23.69,30.18 23.58,30.18 23.57,30.16 v1(23.57,30.18) ; U1.AE5 34.26,65.17 34.01,65.42 v1(33.97,65.42) ; 24.62,32.75 24.85,32.75 v1(25.2,33.1) ; 24.62,32.75 24.91,32.46 24.91,32.27 25.17,32.01 25.25,32.01 U1.J59 ; 24.62,32.75 U1.H57 ; U1.AL20 37.38,57 37.02,57.36 37.02,57.43 36.98,57.47 v1(36.98,57.47) ; 24.69,58.07 24.43,57.82 U1.G18 ; 24.69,58.07 25.08,58.47 U1.H17 ; 24.69,58.07 v1(24.69,58.08) ; v1(152.53,10.25) 152.25,9.97 P2.10 152.25,8.45 v1(152.35,8.35) ; U1.AM23 37.8,54.55 37.8,54.62 37.75,54.67 v1(37.75,54.67) ; v1(31.27,28.59) 31.27,28.57 31.44,28.74 U1.Y63 ; U1.AY11 43.85,61.43 43.98,61.56 v1(44.17,61.56) ; v1(36.49,44.76) 36.49,44.7 36.63,44.57 36.63,44.57 36.94,44.26 U1.AL39 37.1,44 U1.AL40 ; U1.B20 21.37,55.95 U1.C20 U1.C18 21.89,57.3 U1.D18 22.45,57.7 22.77,58.02 ; U1.G5 24.13,64.9 v1(24.13,64.74) 24.13,64.55 U1.G6 24.18,63.99 24.18,63.88 v1(24.05,63.76) 24.18,63.64 24.18,63.56 U1.G8 ; U1.AN7 38.52,64.14 38.27,64.39 v1(38.27,64.49) ; U1.B60 21.39,31.14 21.63,31.38 v1(21.65,31.38) 21.94,31.38 22.46,31.9 U1.D59 ; v1(27.81,57.95) 27.81,58.18 27.56,58.44 26.76,58.44 U1.L17 ; v1(35.05,68.76) 35.23,68.58 U1.AG1 ; v1(28.12,66.17) 28.03,66.17 U1.N3 ; U1.AR33 40.35,48.4 v1(40.35,48.57) ; U1.AR31 39.38,49.87 v1(39.38,49.94) 39.38,49.94 U1.AP29 ; v1(22,36.23) U1.B52 21.44,36.18 20.89,36.18 U1.A52 ; v1(22,36.23) 22,36.01 U1.D53 22.46,35.3 U1.D54 ; v1(22,36.23) 22,36.36 22.46,36.82 U1.D51 22.46,37.18 22.77,37.48 U1.D50 ; U1.D54 U1.F54 v1(24.21,34.98) ; U1.D63 22.46,29.21 22.46,29.45 22.55,29.53 U1.D62 ; U1.AR15 40.22,59.45 v1(40.51,59.16) ; U1.AW42 42.19,42.53 42.19,42.64 v1(42.18,42.65) 42.19,42.66 42.19,42.71 U1.AV41 ; v1(30.54,33) U1.V58 ; U1.AV8 41.51,62.64 41.51,62.55 41.53,62.54 41.54,62.55 v1(41.53,62.55) ; v1(29.06,68.61) 29.23,68.44 U1.T1 ; U1.AT35 40.73,48.01 40.84,48.12 U1.AU33 41.49,48.43 U1.AV33 41.52,48.11 U1.AV34 41.86,47.78 42.14,47.5 42.14,47.39 v1(42.17,47.36) 42.14,47.33 42.14,47.31 U1.AW35 ; U1.AR52 39.73,35.92 39.73,35.54 U1.AP54 39,35.58 38.66,35.58 v1(38.46,35.78) 38.73,36.05 U1.AN52 ; U1.AL54 37.85,35.62 v1(37.85,35.75) 37.85,35.8 U1.AL52 ; U1.AM31 37.76,49.61 v1(38.08,49.94) 38.08,49.87 U1.AN31 38.52,49.43 38.94,49.43 U1.AP31 39.06,49.31 U1.AN32 ; v1(40.47,38.6) 40.76,38.3 U1.AT49 ; v1(40.47,38.6) 40.47,38.57 40.03,38.13 U1.AR49 ; v1(40.47,38.6) 40.73,38.87 U1.AT46 ; U1.AL46 37.38,40 37.12,40.26 v1(37.12,40.42) 37.12,40.62 U1.AL45 ; v1(37.72,30.29) 37.72,30.77 U1.AL61 U1.AL60 ; U1.A18 20.06,57.2 19.94,57.31 v1(19.91,57.31) ; v1(39.6,56.53) 39.63,56.56 39.63,56.76 U1.AP20 ; v1(34.16,59.95) 34.33,60.12 U1.AF14 ; CON10.51 2.29,79.24 v1(2.18,79.14) ; v1(21.99,51.11) 21.99,51.43 21.81,51.61 U1.C27 ; v1(21.99,51.11) 21.65,51.11 U1.B28 U1.A28 20.47,51.27 20.32,51.43 v1(20.32,51.41) ; v1(33.15,73.52) 33.17,73.52 32.9,73.24 R9330.1 ; U1.C27 21.49,52.29 U1.B26 ; U1.AT62 40.36,29.83 U1.AT63 40.36,28.66 40.5,28.52 v1(40.5,28.44) ; D20.2 124.48,70.79 C161.2 ; U1.AN52 38.91,36.4 38.91,36.84 38.73,37.02 U1.AN51 ; U1.AN52 U1.AP52 ; v1(37.8,45.74) 37.8,45.86 U1.AL36 ; v1(24.21,37.47) 24.16,37.47 24.15,37.48 U1.F50 U1.D50 ; v1(153.75,10.25) 153.75,10.25 P2.13 153.75,8.31 v1(153.79,8.27) ; v1(2.26,84.8) 2.29,84.8 2.73,85.24 CON10.39 ; v1(1.96,83.94) 2.44,83.94 2.63,83.75 3.8,83.75 CON10.42 ; v1(37.75,54.67) 37.65,54.77 37.65,54.88 U1.AL22 ; v1(37.75,54.67) 37.75,54.61 37.43,54.29 U1.AL23 ; U1.Y59 31.13,32.13 v1(31.04,32.13) ; U1.AU59 U1.AV59 U1.AW59 42.49,31.48 U1.AW60 ; U1.AW50 42.49,37.58 42.35,37.72 42.35,37.73 v1(42.16,37.92) 41.84,38.24 U1.AV49 ; 21.98,53.69 v1(21.99,53.69) 21.99,54.12 U1.D23 22.49,54.62 22.49,54.66 v1(22.85,55.02) 22.94,55.1 U1.D21 ; U1.AP10 38.92,62.47 v1(38.92,62.54) ; U1.F20 23.78,56.54 v1(24.12,56.19) 24.22,56.1 24.22,55.27 U1.G22 ; U1.D46 U1.F46 v1(24.21,39.99) ; v1(140.65,53.27) 140.79,53.14 PU3.14 ; v1(32.56,30.82) 32.64,30.82 U1.AC61 ; CONSATA.73 v1(97.31,14.33) ; CKRN1.2 14.94,43.2 14.68,42.95 v1(14.68,42.65) 14.79,42.55 CKRN1.4 ; v1(37.65,62.56) 37.29,62.21 U1.AL10 ; U1.AL26 36.87,52.91 36.62,52.91 36.29,53.23 U1.AJ25 ; U1.P62 U1.P63 28.44,28.74 v1(28.6,28.58) ; U1.AN23 38.73,54.19 39.03,53.88 v1(39.03,53.82) ; U1.D42 U1.F42 v1(24.21,42.5) ; U1.R8 U1.R10 28.76,61.81 29.02,61.54 29.02,61.37 v1(29.07,61.32) 29.02,61.27 29.02,61.17 28.77,60.92 28.26,60.92 27.93,61.26 27.93,62.21 U1.N10 ; v1(158.18,10.15) 158.25,10.08 P2.22 ; v1(39.94,61.16) 40.23,60.87 40.4,60.69 40.4,60.37 40.53,60.24 U1.AT13 ; U1.AH19 35.74,57.53 35.74,57.84 U1.AH17 35.99,58.09 36.36,58.46 v1(36.36,58.54) 36,58.9 U1.AH16 ; v1(19.81,61.64) 20.01,61.44 U1.A11 ; U1.AU57 40.87,33.4 v1(40.43,33.83) 40.86,34.26 U1.AU55 ; v1(22.77,57.94) 22.77,58.02 ; 22.77,58.02 22.77,58.17 23.13,58.54 U1.E17 ; U1.AB7 32.34,64.09 v1(32.09,64.09) ; U1.D34 U1.F34 v1(24.21,47.51) ; CON10.54 v1(2.21,77.74) ; GR37.2 v1(36.02,22.95) ; U1.AY33 U1.AW33 ; v1(37.1,47.55) 37.1,47.76 37.42,48.08 U1.AL33 ; U1.AW44 42.49,40.72 v1(42.14,41.07) 41.96,41.25 41.96,41.36 U1.AV43 ; v1(33.62,28.2) 33.69,28.27 U1.AD63 ; v1(2.19,76.24) CON10.57 ; D22.2 129.23,70.91 129.26,70.88 C160.2
  BOTTOM w0.279: CONSATA.45 97.49,21.33 97.56,21.41 v1(97.97,21.41) ; v1(97.44,18.71) 97.44,19.47 97.08,19.83 CONSATA.51 ; v1(180.3,87.07) 180.29,87.07 180.29,87.06 181.59,87.06 182.75,85.9 CON11.13 ; CONSATA.71 95.07,14.83 v1(94.06,15.84) ; CONSATA.3 v1(97.47,31.83) ; U20.24 v1(159.93,75.56) ; v1(154.13,71.98) 153.96,71.81 U20.5 ; CON9.1 v1(135.5,10.43) ; CONSATA.27 96.99,25.83 97.44,26.28 v1(97.44,26.97) ; v1(179.5,43.35) CONWIFI.7 ; CONSATA.33 97.16,24.33 v1(97.28,24.46)
  BOTTOM w0.305: U1.AJ35 35.48,46.73 v1(35.26,46.51) 35.69,46.08 U1.AH36 ; U1.W20 30.74,56.63 v1(30.35,57.02) 29.97,56.64 U1.U20 ; DIMM1.128 66.44,57.35 v1(66.22,57.57) ; v1(179.52,55.68) 179.52,55.67 179.71,55.67 179.89,55.85 CONWIFI.57 ; v1(62.18,71.37) 62.04,71.23 62.04,71.14 61.74,70.84 60.65,70.84 60.64,70.85 DIMM1.173 ; v1(27.26,60.16) 26.93,60.16 U1.L13 26.21,60.89 U1.K12 ; v1(171.53,51.02) 171.94,50.6 CONWIFI.36 ; DIMM1.170 66.56,69.95 v1(66.24,69.64) 66.53,69.35 DIMM1.168 ; v1(60.89,35.74) 60.89,35.76 ; 60.89,35.76 60.89,35.89 60.73,36.05 DIMM1.65 ; 60.89,35.76 60.58,35.45 DIMM1.63 ; v1(66.24,72.6) 66.25,72.6 66.5,72.35 DIMM1.178 ; CONWIFI.23 v1(179.55,47.35) ; U1.AK52 36.23,36.22 U1.AJ52 35.66,36.33 v1(35.53,36.45) 35.53,36.71 U1.AH51 ; v1(61.02,58.86) 61.01,58.85 DIMM1.133 ; v1(34.34,33.06) 34.34,33.02 34.44,32.92 U1.AE58 ; CONWIFI.39 179.75,51.35 179.47,51.64 v1(179.47,52.19) ; v1(62.28,69.92) 62.28,69.82 61.37,68.9 60.91,68.9 60.76,69.05 DIMM1.167 ; v1(181.89,53.23) 181.51,52.85 CONWIFI.45 ; v1(45.87,85.29) 45.87,85.01 46.09,84.79 PQ25.1 ; DIMM1.162 68.8,67.55 69.09,67.83 v1(69.09,68.62) ; U1.AH30 35.77,50.01 35.56,50.23 v1(35.56,50.5) 35.7,50.63 U1.AJ29 ; v1(65.23,28.06) 65.23,28.07 66.34,28.07 66.45,27.95 DIMM1.38 ; v1(30.16,63.48) 30.16,62.8 U1.U9 ; v1(22.3,28.16) 22.49,28.35 U1.D63 ; DIMM1.139 60.71,60.65 v1(61.06,60.99) ; U1.AJ56 36.13,33.4 U1.AH57 35.51,33.37 v1(35.51,33.77) ; CONWIFI.63 181.69,57.35 181.87,57.18 v1(181.87,57.16) ; U1.AH49 35.41,38.28 35.05,37.92 v1(35.05,37.51) 35.17,37.63 U1.AJ50 ; DIMM1.49 60.62,31.25 61.29,31.92 v1(61.39,31.92) ; v1(32.21,61.1) 32.57,61.46 U1.AB10 ; DIMM1.60 65.53,34.55 65.14,34.16 65.14,34.06 v1(65.03,33.94) 65.03,33.84 66.11,32.75 DIMM1.54 ; DIMM1.127 v1(60.88,57.05) ; 61.4,77.45 62.76,76.09 62.76,74.98 v1(62.3,74.52) ; 61.4,77.45 DIMM1.195 ; 61.4,77.45 60.8,78.05 DIMM1.197 ; U20.34 160.33,70.81 v1(160.28,70.76) 160.28,70.45 160.42,70.31 U20.35 ; U1.AH42 35.8,42.15 v1(35.28,41.63) 35.38,41.53 U1.AJ43 ; v1(60.92,72.62) 60.88,72.65 DIMM1.179 ; v1(61.57,74.53) 61.57,74.79 60.71,75.65 DIMM1.189 ; DIMM1.134 66.57,59.15 66.16,58.74 v1(65.46,58.74) 65.46,58.94 66.26,59.75 DIMM1.136 ; DIMM1.28 66.64,24.95 v1(66.3,24.61) 66.56,24.35 DIMM1.26 ; v1(172,47.46) 172.12,47.59 172.12,47.6 CONWIFI.24 ; CONWIFI.29 181.5,48.85 v1(181.89,49.24) ; DIMM1.144 65.72,62.15 64.95,61.39 v1(64.95,60.99) 64.95,60.6 65.2,60.35 DIMM1.138 ; U1.AH34 36.49,47.38 36.61,47.49 37.05,47.49 v1(37.1,47.55) ; U1.J22 v1(26.29,55.59) ; v1(32.51,57.18) 32.51,57.13 32.41,57.03 U1.AB20 ; U1.AH46 35.66,39.72 v1(35.23,39.72) 35.23,39.26 35.57,38.93 U1.AJ47 ; U1.AJ54 35.69,35.03 v1(35.59,35.13) 35.59,35.46 U1.AH53 ; U1.Y10 31.42,62.33 v1(31.13,62.04) 30.84,62.33 U1.V10 ; v1(179.1,41.93) 179.17,41.85 CONWIFI.1 ; U1.AH40 35.67,43.48 v1(35.28,43.1) 35.55,42.83 U1.AJ41 ; DIMM1.185 60.9,74.45 60.94,74.49 v1(60.94,74.53) 60.94,74.85 60.73,75.05 DIMM1.187 ; U1.AH38 35.71,44.78 v1(35.3,44.37) 35.54,44.13 U1.AJ39 ; CONWIFI.51 179.66,54.35 179.45,54.56 v1(179.45,54.6) ; U1.L15 26.71,59.49 26.77,59.56 v1(27.31,59.56) ; v1(57.19,33.94) 58.1,34.85 DIMM1.61 ; v1(181.87,60.62) 181.6,60.35 CONWIFI.75 ; v1(35.25,48.68) U1.AH32 ; U1.AJ27 35.51,51.93 v1(35.3,51.72) 35.74,51.28 U1.AH28 ; v1(26.64,33.1) U1.L58 ; U1.AF15 34.79,59.31 33.73,58.25 v1(33.73,58.12) ; CONWIFI.69 182.35,58.85 183.31,59.82 v1(183.31,59.84) ; U1.L18 26.66,57.52 v1(27.01,57.16) 26.72,56.87 U1.L20 ; U1.AK23 36.61,54.1 36.61,53.99 v1(36.45,53.83) 36.25,54.03 36.25,54.51 U1.AJ23 ; DIMM1.153 60.75,64.85 v1(60.91,64.69) ; v1(64.21,26.66) 64.21,26.46 64.97,25.7 66.02,25.7 66.47,26.15 DIMM1.32 ; v1(65.04,62.76) 65.16,62.87 65.16,62.97 66.13,63.95 DIMM1.150 ; U1.AH44 35.56,40.88 v1(35.22,40.54) 35.53,40.23 U1.AJ45 ; DIMM1.155 61.26,65.45 61.55,65.17 v1(61.55,64.69) 61.55,64.38 61.24,64.08 60.71,64.08 60.53,64.25 DIMM1.151 ; U1.AH24 35.8,53.62 v1(35.57,53.38) 35.71,53.23 U1.AJ25 ; v1(60.89,62.76) 60.58,62.45 DIMM1.145 ; U1.AD21 v1(33.63,55.57) ; v1(181.87,50.13) 181.59,49.85 CONWIFI.33 ; CONWIFI.18 v1(174.31,46.1) ; CONWIFI.30 174.21,49.1 v1(174.4,49.29) ; v1(60.86,38.24) 60.47,37.85 DIMM1.71 ; v1(61.19,24.61) 61.19,24.37 60.87,24.05 DIMM1.25
  BOTTOM w0.356: DIMM1.19 60.81,22.25 v1(60.91,22.35) ; GU1.7 87.01,7.83 v1(87.07,7.89) ; v1(62.84,21.84) 62.73,21.73 62.73,21.61 61.56,20.45 DIMM1.13 ; DIMM1.196 68.95,77.75 v1(69.27,77.44) ; DIMM1.66 66.59,36.35 66.52,36.42 65.43,36.42 65.11,36.1 65.11,35.96 v1(65.03,35.87) ; DIMM1.37 58.5,27.65 57.46,26.61 v1(57.46,25.99) ; PQ5.4 64.25,90.94 ; v1(66.26,74.18) 66.29,74.15 DIMM1.184 ; DIMM1.43 58.5,29.45 58.2,29.15 58.2,28.29 58.09,28.19 v1(58.09,28.16) ; DIMM1.172 66.29,70.55 66.09,70.35 66.09,69.79 v1(66.24,69.64) ; DIMM1.3 56.84,17.45 56.39,17.9 v1(55.32,17.9) ; v1(57.19,33.94) 57.52,33.94 58.41,33.05 DIMM1.55 ; HU4.3 94.86,6.03 94.44,6.44 v1(94.44,6.7) ; v1(66.19,37.73) 66.27,37.73 66.68,38.15 DIMM1.72 ; DIMM1.31 61.01,25.85 61.45,26.29 v1(61.45,26.65) ; PQ5.1 62.7,88.86 62.89,88.68 v1(62.89,88.29) 63.03,88.16 PQ6.1 ; v1(140.21,43.97) 140.26,44.01 PQ13.4 ; v1(66.3,75.89) 66.36,75.95 DIMM1.190 ; DIMM1.9 61.14,19.25 v1(61.24,19.35) 60.74,19.85 DIMM1.11 ; DIMM1.14 65.68,20.75 65.04,21.39 v1(65.04,21.84) 65.13,21.93 65.13,22.07 65.61,22.55 DIMM1.20 ; v1(117.12,69.97) 117.8,70.65 D5.2 ; DIMM1.8 66.36,18.95 v1(65.97,19.35) ; DIMM1.156 v1(66.22,65.75) ; DIMM1.46 66.2,30.35 v1(65.94,30.09) 66.28,29.75 DIMM1.44 ; PQ35.1 v1(105.15,38.56) ; v1(98.27,23.51) 98.1,23.51 97.42,22.83 CONSATA.39 ; v1(69.19,17.29) 69.05,17.15 DIMM1.2 ; v1(69.11,31.92) 69.11,31.13 68.93,30.95 DIMM1.48 ; DIMM1.161 61.71,67.25 62.07,67.61 62.07,67.62 v1(62.28,67.84) ; GU2.3 v1(96.25,10.29)
  BOTTOM w0.381: v1(47.63,71.58) 47.94,71.58 48.53,72.17 C50.2 ; Q7.4 v1(181.96,29.68) ; PR235.2 v1(103.23,38.02) ; D10.2 21.1,82.81 21.47,83.18 v1(22.23,83.18) ; v1(102.67,36.44) 102.78,36.33 C127.1 ; Q7.5 v1(181.31,29.68) ; C126.2 v1(104.87,36.33) ; Q7.1 v1(180.66,29.83)
  BOTTOM w0.406: v1(181.71,67.66) 181.43,67.37 Q5.1 ; v1(32.28,87.47) 32,87.75 D12.2 ; C181.2 173.14,85.93 v1(173.38,85.69) ; R176.2 95.65,70.11 ; v1(181.71,69.31) 181.71,69.03 182.07,68.67 Q5.4
  BOTTOM w0.432: C192.2 v1(150.97,67.94) ; D16.2 64.41,7.7 65.58,8.88 v1(65.58,9.16)
  BOTTOM w0.457: C187.2 177.13,83.02 v1(177.13,83.53) ; v1(179.02,78.96) 179.05,78.99 C183.2 ; PR16.2 36.74,83.72 37.7,84.68 v1(37.7,85.37) ; v1(178.65,38.93) VCB4.2 ; v1(148.62,90.39) 148.62,90.38 VCB1.2 ; v1(162.38,68.32) 162.91,68.32 C191.2 ; v1(97.47,78.09) 97.44,78.12 96.96,78.12 C77.2 ; R189.2 93.38,83.7 93.74,84.05 v1(94.74,84.05) 94.74,84.51 94.93,84.69 SC4.2 ; C69.2 94.81,85.54 94.45,85.89 94.32,85.89 94.12,86.1 v1(94.12,86.43) ; v1(135.99,56.81) 135.99,56.37 PR87.2 ; v1(118.95,74.9) 118.95,75.15 118.61,75.49 R224.2 ; v1(45.46,71.65) 45.46,72.07 C49.2 ; R455.1 101.98,69.94 ; v1(99.85,71.12) 99.51,71.47 C71.2 SC3.2 ; R103.2 23.87,72.87 v1(23.72,73.01) ; R457.1 116.3,78.01 v1(116.28,78.02) ; R222.2 109.46,69.88 v1(109.31,69.74) ; v1(105.77,69.89) 106.15,70.27 C76.2 ; v1(126.26,59.2) 125.66,59.2 125.38,59.47 PC136.2 ; v1(172.42,84.04) 172.54,84.17 C185.2 ; v1(28.83,73.51) 28.83,73.47 28.35,72.99 R86.2 ; SC5.2 96.61,82.91 96.31,83.21 v1(95.8,83.21) ; PQ13.1 138.56,42.71 138.47,42.8 PR77.2 ; C100.2 145.07,79.25 v1(145.49,78.83) ; v1(164.59,80.17) 164.86,80.44 164.86,80.45 C48.2 ; v1(118.47,87.24) 118.27,87.24 118.16,87.13 C72.2 ; v1(35.04,73.28) 34.95,73.19 R400.2 ; PC14.2 18.35,82.03 v1(19.38,81.01) ; C179.2 179.86,74.57 v1(179.88,74.54) ; C78.2 97.13,81.21 v1(97.13,81.5) ; VCB3.2 178.38,35.25 v1(177.98,35.25) ; v1(179.15,83.52) 179.25,83.52 179.72,83.05 C186.2 ; v1(147.78,78.83) 147.72,78.9 147.72,80.01 VCB2.2 ; PC124.2 124.84,68.07 v1(124.61,68.29) ; C193.2 150.99,69.31 150.97,69.29 C192.2 ; v1(172.42,84.93) 172.54,85.06 C180.2 ; v1(98.64,70.49) R456.1 ; SP1.2 116.63,85.87 v1(116.07,85.31) ; C53.2 v1(138.31,78.63) ; v1(46.51,8.17) 46.78,7.9 PC177.2 ; v1(157.99,78.45) 157.99,79.04 158.28,79.33 C190.2 ; PC197.2 149.76,75.57 C195.2 ; v1(150.01,84.68) 149.89,84.8 C103.2 148.56,84.81 C102.2 ; C184.2 v1(179.91,78.96) ; R415.2 22.98,73.41 22.81,73.24 v1(22.81,72.91) 22.93,72.79 22.93,72.65 22.96,72.61 R106.2 ; 31.48,91.1 31.57,91.01 D11.2 ; R96.2 26.46,72.96 v1(26.49,72.99) 26.9,72.99 27.28,72.61 R87.2 ; C101.2 144.96,91.05 ; v1(139.63,56.86) PC72.2 ; PC138.2 v1(119.2,61.19)
  BOTTOM w0.508: CONSATA.76 v1(96.88,34.67) ; v1(73.18,11.85) 74,11.03 J1.5 ; v1(172.16,73.75) 171.63,73.22 Q25.2 ; C1178.2 47.22,32.46 v1(47.25,32.43) ; CON4.2 v1(185.71,18.23) ; v1(47.61,37.38) 47.55,37.32 47.55,37.3 47.22,36.97 46.98,36.97 C1182.2 46.94,38.05 C1181.2 ; PC21.2 55.72,76.45 v1(54.74,75.47) 55.03,75.17 PCE1.2 ; PC97.2 11.5,40.08 PC40.2 ; PC129.2 126.59,68.17 v1(126.19,68.17) ; PC42.2 51.03,84.55 50.73,84.24 50.73,83.91 ; v1(37.54,22.95) 37.44,22.85 PC219.2 ; C98.2 v1(188.04,20.48) ; v1(144.37,85.44) 144.37,85.18 VU2.1 ; v1(172.16,87.85) 172.21,87.9 172.21,87.93 172.29,88 CON11.19 175.06,88 v1(175.34,87.72) ; v1(108.71,61.28) 107.67,61.28 107.36,60.97 U25.1 ; v1(130.05,66.01) 129.49,65.45 PC125.2 ; CON4.4 v1(187.31,18.23) ; CONWIFI.76 v1(178.16,40.75) ; C81.2 97.94,73.81 v1(98,73.87) ; v1(173.94,72.86) 174.1,72.7 Q26.2 ; PC39.2 30,80.15 v1(30.25,79.91) 30.44,79.72 30.44,79.02 SR61.2 ; v1(92.79,10.25) 92.81,10.23 GR26.2 ; PC84.2 14.79,24.16 v1(14.36,24.6) ; 50.73,83.91 v1(50.73,83.91) ; 50.73,83.91 50.87,83.77 51.86,83.77 PC29.2 ; PCE2.2 16.57,72.31 v1(17.93,72.31) ; C114.2 41.1,91.03 ; HQ1.2 39.78,17.33 v1(39.78,18.1) ; CONSATA.77 97.32,12.73 v1(98.32,13.73) ; PC75.2 8.89,16.66 v1(8.19,15.95) ; PC201.2 44.57,85.79 44.07,85.28 44.05,85.28 44.05,85.29 ; PR18.2 51.2,75.91 PR13.2 51.03,74.74 v1(51.01,74.72) ; v1(46.67,81.08) 46.61,81.08 46.49,80.96 X1.2 ; v1(46.51,8.86) 46.51,9.03 46.91,9.44 PU9.2 ; PC28.2 47.61,81.84 46.43,83.02 PC203.2 46.83,83.55 47.47,83.55 47.82,83.89 v1(47.82,83.9) ; v1(56.97,4.92) 57.14,4.76 Q35.2 ; v1(36.72,75.6) 36.72,76.05 SR59.2 ; CON7.3 13.3,64.87 11.69,66.49 v1(11.28,66.49) ; v1(136.7,9.06) 137.21,9.06 137.85,8.42 CON9.8 v1(136.68,7.8) ; v1(75.52,91.1) 76.32,90.3 HQ3.2 ; PC225.2 v1(98.67,38.16) ; PC92.2 0.92,34.74 ; v1(51.79,55.34) 51.78,55.35 HR43.2 50.89,55.35 SR19.2 ; PQ8.2 97.07,38.77 v1(97.79,38.04) ; v1(147.37,83.2) 147.08,83.49 VU2.3 ; CB7.2 96.29,90.99 ; v1(159.48,85.17) 159.46,85.17 159.44,85.19 CON6.7 ; v1(31.13,79.91) 31.14,79.91 31.21,79.85 31.21,79.26 SR63.2 ; v3(10.59,48.33) 11.04,47.88 CKX1.2 ; v1(44.06,85.29) 44.05,85.29 ; 44.05,85.29 43.33,85.29 43.1,85.52 PC202.2 ; C430.2 119.58,2.37 v1(119.78,2.18) ; 126.96,57.22 PC200.2 126.4,57.94 ; PC13.2 18.06,76.22 v1(18.06,76.79) ; v1(128.75,7.8) CON9.9 v1(131.49,7.8) ; CON1.1 v1(166.75,86.61) ; v1(78.4,18.03) 77.67,18.03 DIMM1.207 77.23,14.32 v1(78.56,14.32) ; v1(118.6,59.58) 118.78,59.4 119.89,59.4 PR152.1 ; v1(112.07,56.75) 111.79,57.03 PC189.2 ; PC78.2 v1(9.3,19.92) ; v1(15.14,44.95) 14.89,44.95 14.16,45.68 CKX1.4 ; PQ28.2 53.98,87.47 54.11,87.34 v1(54.13,87.34) 54.15,87.34 54.62,87.81 PC190.2 ; v1(62.89,88.29) 62.78,88.18 62.41,88.18 61.63,87.41 PR54.2 ; v1(146.89,7.97) 146.85,8.01 P2.41 ; v1(78.49,79.39) 78.49,80.79 78.23,81.05 DIMM1.208 73.31,81.05 v1(72.76,81.6) ; PC7.2 14.37,73.8 v1(14.37,73.39) ; v1(13.06,27.93) 13.1,27.88 PR129.2 13.54,27.21 13.82,27.49 PR120.2 ; v1(168.1,10.18) 168.15,10.13 P2.42 ; R225.2 116.41,79.47 v1(116.54,79.34) ; C75.2 121.04,71.54 v1(120.47,72.1) ; PC175.2 50.08,15.81 v1(50.24,15.97) ; HR45.1 17.04,57.89 17.04,57.24 v1(17.71,56.58) ; v1(12.17,27.92) 12.06,27.81 PR122.2 ; AC1.2 53,68.46 53.06,68.52 53.57,68.52 54.15,69.11 v1(55.93,69.11) ; v1(16.61,48.1) 16.28,48.43 CKC1.2 ; v1(155.91,87.29) 155.91,89.27 156.62,89.99 CON6.1 ; PC176.2 46.75,15.78 v1(46.56,15.97) 46.01,15.42 PR191.2 ; VU1.3 v1(145.42,87.6) ; C159.2 126.26,70.27 v1(126.14,70.15) ; v1(147.27,87.6) 147.27,87.15 147.32,87.1 VU1.1 ; v1(47.33,81.08) 47.39,81.01 X1.3 ; PC65.2 v1(135.3,49.08) 135.3,49.61 PC69.2 ; SC7.2 101.56,11.6 v1(101.17,11.6) ; GR38.2 v1(32.46,22.32) ; v1(28.87,77.3) PC32.2 ; v1(60.86,38.24) 60.66,38.45 57.13,38.45 56.64,38.94 D3CE22.2 ; v1(140.62,45.32) 140.52,45.41 PC57.2 PC61.2 ; VU5.3 v1(185.06,30.7) ; VU4.3 175.23,37.89 v1(175.36,38.02) ; v1(51.51,58.89) 51.21,58.89 51.1,59 50.82,59 50.32,59.51 HC5.2 ; v1(104.98,68.52) 105.33,68.87 U11.4 ; PR241.2 106.05,35.12 v1(106.3,34.87) ; CON8.8 122.5,72.99 v1(121.62,72.1) 121.01,72.71 CON8.9 ; C161.2 124.16,70.27 v1(123.62,69.74) 123.62,69.93 R348.2 ; v1(147.59,77.32) 147.59,75.21 148.08,74.72 148.8,74.72 149.29,74.22 CKC6.2 ; D3CE27.2 56.65,47.44 56.54,47.54 D3CE6.2 56.54,49.19 56.38,49.35 v1(56.36,49.35) ; v1(34.49,75.97) 34.44,75.91 SR60.2 ; C125.2 101.14,10.36 v1(101.14,10.96) ; v1(184.12,30.84) 184.1,30.83 C97.2 ; GR36.2 31.35,22.29 v1(31.32,22.32) ; CON10.60 v1(2.19,74.49) ; v1(38.51,80.11) 38.36,79.96 CKC4.2 ; PR124.1 11.04,27.69 v1(10.82,27.91) 10.37,27.91 9.97,27.51 PR126.2 ; v1(136.82,42.46) 137.39,42.46 PR77.2 ; v1(8.09,18) 8.17,18.08 PC77.2 8.8,18.64 8.91,18.75 PR132.2 ; v1(69.04,11.85) 69,11.82 J1.1 ; Q38.2 118.4,67.64 118.6,67.84 v1(118.6,68.73) ; v1(93.17,80.71) 93.17,81.08 94.14,82.05 X2.2 ; v1(149.05,67.82) 148.74,68.13 148.74,69.82 149.3,70.37 CKC5.2 ; Q19.2 37.4,91.03 ; PC27.2 51.84,78.5 51.74,78.4 51.74,78.39 51.72,78.36 v1(51.72,78.35) ; v1(50.12,6.37) 49.4,6.37 48.95,6.83 PC174.2 ; PR85.1 135.47,48.22 v1(135.31,48.38) ; v1(179.15,62.58) 179.71,62.58 179.93,62.36 CONWIFI.77 181.31,61.45 v1(181.88,62.02) ; AC4.2 49.1,63.97 49.46,63.62 52.5,63.62 v1(53.47,62.65) ; GC3.2 93.51,6.57 v1(93.64,6.7) ; SR78.2 42.98,72.64 v1(43.39,73.05) ; C1179.2 47.65,42.14 v1(47.65,42.61) 47.25,42.61 C1180.2 ; C160.2 128.68,70.3 v1(128.53,70.15) ; C195.2 149.05,76.27 148.49,76.83 v1(148.49,77.32) ; v1(143.33,87.6) 143.02,87.91 F3U1.4 ; v1(15.7,26.74) 15.86,26.57 PR119.2 16.58,26.6 16.58,27.21 16.45,27.33 HC8.2 ; X2.3 96.18,81.5 v1(96.5,81.5) ; VCB5.2 v1(188.29,32.35) ; GR35.2 v1(33.73,22.32) ; C80.2 94.14,72.14 v1(93.91,72.38) ; PQ7.2 v1(102.1,35.95) ; HC3.2 v1(14.66,31.03) ; GC4.2 v1(96.69,6.99) ; C147.2 174.16,69.22 v1(173.81,69.56) ; v1(187.05,25.54) D9.1 ; PC171.2 118.25,2 ; v1(184.76,17.2) CON4.6 v1(183.61,18.51) ; v1(14.2,62.22) 12.83,62.22 11.68,61.07 CON7.5 ; v1(171.02,67.4) 171.12,67.51 T32.1 ; R304.2 v1(182.45,31.72) ; v1(15.77,44.95) 15.77,45.51 CKC2.2 ; v1(24.08,82.11) 24,82.19 CN1.2 ; VU3.3 v1(183.87,36) ; HC7.2 v1(98.21,3.74)
  BOTTOM w0.635: 144.65,8.09 P2.43 v1(145.92,6.5)
  vias: v1(0.92,91.08) v1(0.92,88.66) v1(0.89,87.27) v1(0.89,84.17) v1(0.89,81.25) v1(0.89,76.93) v1(0.89,72.89) v1(0.92,46.96) v1(0.92,44.16) v1(0.92,42.38) v1(0.92,39.84) v1(0.92,37.3) v1(0.92,35.53) v1(0.92,32.99) v1(0.92,30.45) v1(0.92,27.91) v1(0.92,25.37) v1(0.92,22.83) v1(0.92,20.29) v1(0.92,17.75) v1(0.92,16.48) v1(0.92,15.21) v1(0.92,12.67) v1(0.89,11.9) v1(1.91,9.67) v1(2.24,86.78) v1(2.87,71.85) v1(2.9,7.33) v1(2.9,5.68) v1(2.9,3.9) v1(2.9,2.25) v1(2.9,1.62) v1(3.41,68.67) v1(3.41,65.37) v1(3.41,62.45) v1(3.41,59.53) v1(3.41,56.61) v1(3.41,53.31) v1(3.41,50.97) v1(3.38,0.98) v1(4.01,0.98) v1(4.65,0.98) v1(4.9,69.64) v1(4.9,69) v1(5.24,85.61) v1(5.35,46.58) v1(5.42,77.86) v1(5.99,46.59) v1(6.1,85.41) v1(6.33,89.53) v1(6.3,0.98) v1(6.38,59.91) v1(6.64,46.59) v1(6.73,53.96) v1(7.06,1.62) v1(7.06,0.98) v1(7.16,29.39) v1(7.28,46.58) v1(7.44,31.21) v1(7.44,30.55) v1(7.53,29.91) v1(7.82,0.98) v1(7.95,46.59) v1(8.46,0.98) v1(8.59,46.6) v1(9.23,46.58) v1(9.6,0.98) v1(9.78,83.43) v1(9.87,46.57) v1(10.01,42.55) v1(10.01,41.91) v1(9.98,40.8) v1(9.98,40.16) v1(10.26,89.27) v1(10.9,89.27) v1(10.94,85.45) v1(12.02,0.98) v1(12.35,35.55) v1(12.35,34.92) v1(13.01,89.45) v1(13.13,87.83) v1(13.65,36.62) v1(13.64,35.98) v1(13.64,35.35) v1(13.62,34.71) v1(13.79,0.98) v1(15.85,62.12) v1(16.73,36.16) v1(16.72,35.52) v1(16.71,34.88) v1(16.82,87.9) v1(16.89,89.12) v1(16.97,0.98) v1(17.18,68.81) v1(18.42,66.59) v1(19.51,0.98) v1(21.92,0.98) v1(23.95,91.1) v1(25.02,0.9) v1(26.11,3.14) v1(26.37,80.78) v1(26.49,91.1) v1(27.71,80.87) v1(28.14,4.89) v1(29.03,91.1) v1(29.78,81.69) v1(30.42,81.73) v1(31.06,81.75) v1(31.57,91.1) v1(31.7,4.89) v1(32.35,81.64) v1(32.35,81) v1(33.12,8.35) v1(33.11,6.04) v1(34.07,10.92) v1(34.11,91.1) v1(34.91,78.64) v1(36.02,22.32) v1(36.65,91.1) v1(36.62,12.7) v1(37.14,39.44) v1(39.19,91.1) v1(39.6,12.64) v1(41.73,91.1) v1(41.86,11.02) v1(42.86,8.6) v1(42.89,5.94) v1(42.89,3.65) v1(43,0.98) v1(45.59,0.91) v1(47.58,91.1) v1(48.13,0.91) v1(50.5,26.41) v1(50.67,0.91) v1(51.13,91.1) v1(51.11,6.98) v1(51.64,15.97) v1(53.21,0.91) v1(54.07,53.94) v1(54.69,54.09) v1(55.75,0.91) v1(57.48,10.51) v1(58.29,0.91) v1(58.77,88.78) v1(59.23,10.51) v1(60.83,0.91) v1(61.04,91.1) v1(61.49,4.2) v1(62.69,49.34) v1(62.89,4.18) v1(63.37,0.91) v1(64.97,49.34) v1(65.91,0.91) v1(66.37,91.1) v1(67.87,81.6) v1(68.45,0.91) v1(69.09,71.42) v1(69.09,70.78) v1(69.75,79.94) v1(70.38,79.94) v1(70.63,73.21) v1(70.99,0.91) v1(71.26,73.21) v1(71.4,81.6) v1(71.9,73.21) v1(72.53,73.21) v1(72.7,69.11) v1(73.53,0.91) v1(76.07,0.91) v1(77.9,68.45) v1(78.61,0.91) v1(79.83,91.1) v1(79.91,79.39) v1(80.54,79.39) v1(81.15,0.91) v1(82.3,10.11) v1(82.3,9.48) v1(82.93,10.11) v1(82.93,9.48) v1(83.69,0.91) v1(84.41,91.1) v1(86.23,0.91) v1(87.99,27.65) v1(88.11,25.47) v1(88.34,26.15) v1(88.77,0.91) v1(89.26,68.39) v1(89.46,66.29) v1(89.45,61.76) v1(89.49,71.21) v1(89.49,70.58) v1(89.49,69.94) v1(89.74,91.1) v1(90.69,64.13) v1(91.31,0.91) v1(92.1,38.8) v1(92.36,37.15) v1(93.14,12.87) v1(93.85,0.91) v1(94.16,20.31) v1(94.51,17.77) v1(95.05,12.46) v1(95.33,91.1) v1(95.94,46.8) v1(96.36,40.17) v1(96.29,1.9) v1(96.72,45.76) v1(98.83,1.9) v1(99.26,45.66) v1(99.19,19.22) v1(99.87,21.4) v1(100.03,46.85) v1(100.28,91.1) v1(101.37,1.9) v1(103.91,1.9) v1(105.58,62.34) v1(106.45,1.9) v1(107.09,1.9) v1(107.72,1.9) v1(108.36,1.9) v1(108.99,1.9) v1(109.45,43.47) v1(109.41,42.14) v1(109.88,43.93) v1(109.97,43.1) v1(109.98,42.46) v1(109.98,41.75) v1(110.03,40.33) v1(111.53,1.9) v1(111.63,43.71) v1(111.66,43.04) v1(111.61,42.36) v1(111.61,41.67) v1(114.07,1.9) v1(114.25,40.38) v1(116.08,62.91) v1(116.61,1.9) v1(118.01,59.25) v1(118.44,1.85) v1(120.09,0.91) v1(120.88,65.5) v1(121.39,8.53) v1(121.62,9.19) v1(122.12,55.37) v1(122.39,55.95) v1(122.93,5.08) v1(122.89,0.91) v1(123.34,45.61) v1(124.48,5.2) v1(125.25,55.11) v1(125.52,56.88) v1(125.58,55.69) v1(126.26,57.19) v1(126.44,0.91) v1(127.92,7.56) v1(129.43,60.55) v1(129.49,0.91) v1(131.6,87.6) v1(132.23,87.6) v1(132.92,0.91) v1(133.2,44.57) v1(133.61,44.06) v1(134.06,45.76) v1(134.09,45.13) v1(134.11,44.49) v1(134.16,43.73) v1(135.08,54.6) v1(135.54,76.29) v1(135.76,54.6) v1(136.15,57.47) v1(136.1,47.51) v1(136.09,0.91) v1(136.18,76.28) v1(137.06,59.92) v1(137.69,59.92) v1(139.52,0.91) v1(139.73,59.26) v1(139.73,58.63) v1(142.27,85.41) v1(142.74,60.22) v1(142.74,59.49) v1(142.83,60.85) v1(142.9,85.44) v1(142.95,0.91) v1(143.56,48.36) v1(143.97,13.68) v1(143.97,12.92) v1(143.97,12.16) v1(144.65,8.5) v1(144.81,53.74) v1(146.25,0.91) v1(146.41,5.53) v1(148.29,14.06) v1(148.31,5.5) v1(148.82,15.79) v1(148.92,14.06) v1(149.05,13.43) v1(149.56,0.91) v1(149.81,13.43) v1(149.99,16.12) v1(150.24,16.88) v1(150.45,13.43) v1(150.98,6.72) v1(151.36,23.1) v1(151.97,24.22) v1(152.07,20.57) v1(152.2,6.77) v1(152.6,0.91) v1(153.06,7.05) v1(154.1,5.53) v1(154.99,26.84) v1(155.04,6.37) v1(155.4,24.86) v1(155.63,7.31) v1(155.65,5.53) v1(155.78,0.91) v1(156.16,16.73) v1(156.72,44.09) v1(157.08,12.95) v1(157.05,11.7) v1(157.68,59.28) v1(157.86,43.32) v1(158.32,52.54) v1(158.52,11.8) v1(159.16,11.75) v1(160.43,16.83) v1(160.71,13.25) v1(160.86,50.92) v1(160.89,48.94) v1(161.22,11.65) v1(161.34,79.9) v1(161.98,12.13) v1(163.17,34.13) v1(163.22,79.87) v1(163.81,48.48) v1(163.91,52.34) v1(163.93,46.14) v1(164.68,34.33) v1(165.61,53.1) v1(165.86,50.77) v1(166.45,57.37) v1(166.4,33.86) v1(166.7,15.21) v1(167.34,15.21) v1(167.59,47.39) v1(167.97,15.21) v1(168.1,10.81) v1(168.73,15.21) v1(169.01,50.79) v1(169.9,55.34) v1(171.3,11.45) v1(171.81,57.55) v1(174.03,39.46) v1(174.09,41.55) v1(174.4,40.28) v1(175.77,59.78) v1(175.97,55.26) v1(176.71,63.01) v1(177.54,55.44) v1(178.13,65.63) v1(178.16,45.58) v1(178.18,39.39) v1(178.64,12.16) v1(178.94,57.42) v1(179.48,45.84) v1(181.87,45.41) v1(181.81,11.4) v1(181.89,63.87) v1(181.88,62.68) v1(181.89,56.52) v1(181.89,55.89) v1(181.89,55.25) v1(181.89,47.34) v1(181.94,9.49) v1(182.07,66.77) v1(182.45,20.54) v1(182.45,19.65) v1(182.45,8.86) v1(182.58,12.16) v1(182.73,66.77) v1(183.34,66.26) v1(183.97,66.26) v1(183.97,59.82) v1(184.35,12.16) v1(184.61,8.86) v1(185.12,11.4) v1(185.12,9.62) v1(185.26,47.17) v1(185.22,45.51) v1(185.33,43.35) v1(185.39,41.8) v1(185.5,79.21) v1(185.62,82.01) v1(187.17,13.71) v1(188.29,82.01) v1(188.29,79.09) v1(189.08,71.42) v1(189.08,69.61) v1(189.1,67.68) v1(189.1,65.65) v1(189.1,63.47) v1(189.08,61.03) v1(189.1,58.77) v1(189.1,56.41) v1(189.1,53.87) v1(189.08,51.66) v1(189.08,49.47) v1(189.1,47.19) v1(189.08,44.67) v1(189.1,42.41) v1(189.1,15.51) v3(6,56.86) v3(6,55.97) v3(6,55.06) v3(6.73,48.3) v3(7.09,49.19) v3(7.65,48.3) v3(7.8,28.9) v3(7.98,49.17) v3(8.28,29.76) v3(8.43,28.08) v3(8.56,48.28) v3(8.74,28.95) v3(8.87,49.14) v3(9.48,48.3) v3(9.76,49.17) v3(10.64,47.01) v3(96.22,67.15) v3(96.22,66.26) v3(96.22,65.37) v3(96.24,64.43) v3(97.79,54.3) v3(98.68,54.63) v3(98.68,53.74) v3(98.7,52.84) v3(98.71,51.91) v3(100.15,67.15) v3(100.15,66.26) v3(100.15,65.37) v3(100.15,64.43) v3(103.05,67.12) v3(103.05,66.21) v3(104.32,43.45) v3(105.08,6.65) v3(105.54,11.5) v3(105.79,7.18) v3(110.82,51.53) v3(110.82,50.62) v3(110.82,49.73) v3(110.95,47.98) v3(110.95,47.07) v3(110.97,46.1) v3(119.23,40.23) v3(120.19,40.23) v3(120.77,43.96) v3(120.78,42.16) v3(120.79,43.06) v3(121.77,40.19) v3(122.16,5.08) v3(122.26,39.45) v3(122.7,40.24) v3(123.17,39.44) v3(124.12,39.43) v3(124.56,40.22) v3(125.77,37.92) v3(126.14,56.43) v3(126.16,55.19) v3(126.55,38.34) v3(127.15,37.69) v3(133.28,42) v3(133.3,42.89) v3(134.16,42.05) v3(134.14,41.14) v3(134.19,42.97) v3(137.97,27.07) v3(138.96,59.1) v3(138.96,58.2) v3(139.52,72.75) v3(140.41,72.75) v3(141.3,72.75) v3(142.05,60.74) v3(142.06,59.85) v3(142.19,72.75) v3(151.72,76.9) v5(30.79,21.4) v5(30.79,20.59) v5(30.79,19.78) v5(30.79,18.97) v5(31.6,21.4) v5(31.6,20.59) v5(31.6,19.78) v5(31.6,18.97) v5(32.41,21.4) v5(32.41,20.59) v5(32.41,19.78) v5(32.41,18.97) v5(33.22,21.4) v5(33.22,20.59) v5(33.22,19.78) v5(33.22,18.97) v5(34.04,21.4) v5(34.04,20.59) v5(34.04,19.78) v5(34.04,18.97) v5(34.85,21.4) v5(34.85,20.59) v5(34.85,19.78) v5(34.85,18.97) v5(35.66,21.4) v5(35.66,20.59) v5(35.66,19.78) v5(35.66,18.97) v5(36.48,21.4) v5(36.48,20.59) v5(36.48,19.78) v5(36.48,18.97) v5(37.29,21.4) v5(37.29,20.59) v5(37.29,19.78) v5(37.29,18.97) v5(45.37,64.25) v5(45.37,63.44) v5(45.37,62.63) v5(45.37,61.82) v5(46.18,65.07) v5(46.18,64.25) v5(46.18,63.44) v5(46.18,62.63) v5(46.18,61.82) v5(46.18,61) v5(46.18,60.19) v5(46.99,65.88) v5(46.99,65.07) v5(46.99,64.25) v5(46.99,63.44) v5(46.99,62.63) v5(46.99,61.82) v5(46.99,61) v5(46.99,60.19) v5(46.99,59.38) v5(47.8,65.88) v5(47.8,65.07) v5(47.8,64.25) v5(47.8,63.44) v5(47.8,62.63) v5(47.8,61.82) v5(47.8,61) v5(47.8,60.19) v5(47.8,59.38) v5(48.62,65.88) v5(48.62,65.07) v5(48.62,64.25) v5(48.62,63.44) v5(48.62,62.63) v5(48.62,61.82) v5(48.62,61) v5(48.62,60.19) v5(48.62,59.38) v5(49.43,65.88) v5(49.43,65.07) v5(49.43,64.25) v5(49.43,63.44) v5(49.43,62.63) v5(49.43,61.82) v5(49.43,61) v5(49.43,60.19) v5(49.43,59.38) v5(50.24,65.88) v5(50.24,65.07) v5(50.24,64.25) v5(50.24,63.44) v5(50.24,62.63) v5(50.24,61.82) v5(50.24,61) v5(50.24,60.19) v5(50.24,59.38) v5(51.06,65.07) v5(51.06,64.25) v5(51.06,63.44) v5(51.06,62.63) v5(51.06,61.82) v5(51.06,61) v5(51.06,60.19) v5(51.87,64.25) v5(51.87,63.44) v5(51.87,62.63) v5(51.87,61.82) v5(51.87,61) v5(138.91,31.13) v5(138.91,30.32) v5(138.91,29.51) v5(138.91,28.69) v5(138.91,27.88) v5(139.73,31.95) v5(139.73,31.13) v5(139.73,30.32) v5(139.73,29.51) v5(139.73,28.69) v5(139.73,27.88) v5(139.73,27.07) v5(140.54,32.76) v5(140.54,31.95) v5(140.54,31.13) v5(140.54,30.32) v5(140.54,29.51) v5(140.54,28.69) v5(140.54,27.88) v5(140.54,27.07) v5(140.54,26.26) v5(141.35,32.76) v5(141.35,31.95) v5(141.35,31.13) v5(141.35,30.32) v5(141.35,29.51) v5(141.35,28.69) v5(141.35,27.88) v5(141.35,27.07) v5(141.35,26.26) v5(142.17,32.76) v5(142.17,31.95) v5(142.17,31.13) v5(142.17,30.32) v5(142.17,29.51) v5(142.17,28.69) v5(142.17,27.88) v5(142.17,27.07) v5(142.17,26.26) v5(142.98,32.76) v5(142.98,31.95) v5(142.98,31.13) v5(142.98,30.32) v5(142.98,29.51) v5(142.98,28.69) v5(142.98,27.88) v5(142.98,27.07) v5(142.98,26.26) v5(143.79,32.76) v5(143.79,31.95) v5(143.79,31.13) v5(143.79,30.32) v5(143.79,29.51) v5(143.79,28.69) v5(143.79,27.88) v5(143.79,27.07) v5(143.79,26.26) v5(144.6,31.95) v5(144.6,31.13) v5(144.6,30.32) v5(144.6,29.51) v5(144.6,28.69) v5(144.6,27.88) v5(144.6,27.07) v5(145.26,73.83) v5(145.26,73.02) v5(145.26,72.2) v5(145.26,71.39) v5(145.26,70.58) v5(145.42,31.13) v5(145.42,30.32) v5(145.42,29.51) v5(145.42,28.69) v5(145.42,27.88) v5(146.08,74.64) v5(146.08,73.83) v5(146.08,73.02) v5(146.08,72.2) v5(146.08,71.39) v5(146.08,70.58) v5(146.08,69.77) v5(146.89,75.46) v5(146.89,74.64) v5(146.89,73.83) v5(146.89,73.02) v5(146.89,72.2) v5(146.89,71.39) v5(146.89,70.58) v5(146.89,69.77) v5(146.89,68.95) v5(147.7,75.46) v5(147.7,74.64) v5(147.7,73.83) v5(147.7,73.02) v5(147.7,72.2) v5(147.7,71.39) v5(147.7,70.58) v5(147.7,69.77) v5(147.7,68.95) v5(148.52,75.46) v5(148.52,74.64) v5(148.52,73.83) v5(148.52,73.02) v5(148.52,72.2) v5(148.52,71.39) v5(148.52,70.58) v5(148.52,69.77) v5(148.52,68.95) v5(149.33,75.46) v5(149.33,74.64) v5(149.33,73.83) v5(149.33,73.02) v5(149.33,72.2) v5(149.33,71.39) v5(149.33,70.58) v5(149.33,69.77) v5(149.33,68.95) v5(150.14,75.46) v5(150.14,74.64) v5(150.14,73.83) v5(150.14,73.02) v5(150.14,72.2) v5(150.14,71.39) v5(150.14,70.58) v5(150.14,69.77) v5(150.14,68.95) v5(150.95,74.64) v5(150.95,73.83) v5(150.95,73.02) v5(150.95,72.2) v5(150.95,71.39) v5(150.95,70.58) v5(150.95,69.77) v5(151.77,73.83) v5(151.77,73.02) v5(151.77,72.2) v5(151.77,71.39) v5(151.77,70.58) v5(157.46,7.56) v5(157.46,6.75) v5(157.46,5.94) v5(157.46,5.12) v5(157.46,4.31) v5(157.46,3.5) v5(157.46,2.68) v5(157.46,1.87) v5(157.46,1.06) v5(158.27,7.56) v5(158.27,6.75) v5(158.27,5.94) v5(158.27,5.12) v5(158.27,4.31) v5(158.27,3.5) v5(158.27,2.68) v5(158.27,1.87) v5(158.27,1.06) v5(159.08,7.56) v5(159.08,6.75) v5(159.08,5.94) v5(159.08,5.12) v5(159.08,4.31) v5(159.08,3.5) v5(159.08,2.68) v5(159.08,1.87) v5(159.08,1.06) v5(159.89,7.56) v5(159.89,6.75) v5(159.89,5.94) v5(159.89,5.12) v5(159.89,4.31) v5(159.89,3.5) v5(159.89,2.68) v5(159.89,1.87) v5(159.89,1.06) v5(160.71,7.56) v5(160.71,6.75) v5(160.71,5.94) v5(160.71,5.12) v5(160.71,4.31) v5(160.71,3.5) v5(160.71,2.68) v5(160.71,1.87) v5(160.71,1.06) v5(161.52,7.56) v5(161.52,6.75) v5(161.52,5.94) v5(161.52,5.12) v5(161.52,4.31) v5(161.52,3.5) v5(161.52,2.68) v5(161.52,1.87) v5(161.52,1.06) v5(162.33,7.56) v5(162.33,6.75) v5(162.33,5.94) v5(162.33,5.12) v5(162.33,4.31) v5(162.33,3.5) v5(162.33,2.68) v5(162.33,1.87) v5(162.33,1.06) v5(163.15,7.56) v5(163.15,6.75) v5(163.15,5.94) v5(163.15,5.12) v5(163.15,4.31) v5(163.15,3.5) v5(163.15,2.68) v5(163.15,1.87) v5(163.15,1.06) v5(163.96,7.56) v5(163.96,6.75) v5(163.96,5.94) v5(163.96,5.12) v5(163.96,4.31) v5(163.96,3.5) v5(163.96,2.68) v5(163.96,1.87) v5(163.96,1.06) v5(164.77,7.56) v5(164.77,6.75) v5(164.77,5.94) v5(164.77,5.12) v5(164.77,4.31) v5(164.77,3.5) v5(164.77,2.68) v5(164.77,1.87) v5(164.77,1.06) v5(165.58,7.56) v5(165.58,6.75) v5(165.58,5.94) v5(165.58,5.12) v5(165.58,4.31) v5(165.58,3.5) v5(165.58,2.68) v5(165.58,1.87) v5(165.58,1.06) v5(166.4,7.56) v5(166.4,6.75) v5(166.4,5.94) v5(166.4,5.12) v5(166.4,4.31) v5(166.4,3.5) v5(166.4,2.68) v5(166.4,1.87) v5(166.4,1.06) v5(167.21,7.56) v5(167.21,6.75) v5(167.21,5.94) v5(167.21,5.12) v5(167.21,4.31) v5(167.21,3.5) v5(167.21,2.68) v5(167.21,1.87) v5(167.21,1.06) v5(168.02,7.56) v5(168.02,6.75) v5(168.02,5.94) v5(168.02,5.12) v5(168.02,4.31) v5(168.02,3.5) v5(168.02,2.68) v5(168.02,1.87) v5(168.02,1.06) v5(168.84,7.56) v5(168.84,6.75) v5(168.84,5.94) v5(168.84,5.12) v5(168.84,4.31) v5(168.84,3.5) v5(168.84,2.68) v5(168.84,1.87) v5(168.84,1.06) v5(169.65,7.56) v5(169.65,6.75) v5(169.65,5.94) v5(169.65,5.12) v5(169.65,4.31) v5(169.65,3.5) v5(169.65,2.68) v5(169.65,1.87) v5(169.65,1.06) v5(170.46,7.56) v5(170.46,6.75) v5(170.46,5.94) v5(170.46,5.12) v5(170.46,4.31) v5(170.46,3.5) v5(170.46,2.68) v5(170.46,1.87) v5(170.46,1.06) v5(181.92,90.75) v5(181.92,89.93) v5(181.92,89.12) v5(181.92,88.31) v5(181.92,87.49) v5(181.92,86.68) v5(181.92,85.87) v5(181.92,85.06) v5(181.92,84.24) v5(182.73,90.75) v5(182.73,89.93) v5(182.73,89.12) v5(182.73,88.31) v5(182.73,87.49) v5(182.73,86.68) v5(182.73,85.87) v5(182.73,85.06) v5(182.73,84.24) v5(183.54,90.75) v5(183.54,89.93) v5(183.54,89.12) v5(183.54,88.31) v5(183.54,87.49) v5(183.54,86.68) v5(183.54,85.87) v5(183.54,85.06) v5(183.54,84.24) v5(184.35,90.75) v5(184.35,89.93) v5(184.35,89.12) v5(184.35,88.31) v5(184.35,87.49) v5(184.35,86.68) v5(184.35,85.87) v5(184.35,85.06) v5(184.35,84.24) v5(185.17,90.75) v5(185.17,89.93) v5(185.17,89.12) v5(185.17,88.31) v5(185.17,87.49) v5(185.17,86.68) v5(185.17,85.87) v5(185.17,85.06) v5(185.17,84.24) v5(185.98,90.75) v5(185.98,89.93) v5(185.98,89.12) v5(185.98,88.31) v5(185.98,87.49) v5(185.98,86.68) v5(185.98,85.87) v5(185.98,85.06) v5(185.98,84.24) v5(186.79,90.75) v5(186.79,89.93) v5(186.79,89.12) v5(186.79,88.31) v5(186.79,87.49) v5(186.79,86.68) v5(186.79,85.87) v5(186.79,85.06) v5(186.79,84.24) v5(187.61,90.75) v5(187.61,89.93) v5(187.61,89.12) v5(187.61,88.31) v5(187.61,87.49) v5(187.61,86.68) v5(187.61,85.87) v5(187.61,85.06) v5(187.61,84.24) v5(188.42,90.75) v5(188.42,89.93) v5(188.42,89.12) v5(188.42,88.31) v5(188.42,87.49) v5(188.42,86.68) v5(188.42,85.87) v5(188.42,85.06) v5(188.42,84.24)
