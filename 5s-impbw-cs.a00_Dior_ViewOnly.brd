# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_SMDAT2: length 5.1
  TOP w0.102: v1(154.81,71.98) 154.81,72.66 HT97.1
  BOTTOM w0.102: U20.3 153.72,70.81 153.9,70.63 154.38,70.63 154.81,71.06 v1(154.81,71.98)
TP_U7: length 3.2
  TOP w0.089: T9.1 28.88,63.09 v1(29.24,63.44)
  BOTTOM w0.089: v1(29.24,63.44) 29.28,63.44 U1.U7
TP_V21: length 1.3
  TOP w0.089: PT8.1 30.51,55.16 30.38,55.29 v1(30.38,55.57)
  BOTTOM w0.089: v1(30.38,55.57) 30.38,55.57 U1.V21
TP_Y20: length 2.5
  TOP w0.089: v1(31.16,57.05) 31.16,57.78 30.58,58.36 PT2.1
  BOTTOM w0.089: U1.Y20 31.58,56.63 v1(31.16,57.05)
TPM_3P3V_R: length 4.8
  TOP w0.254: U9.5 129.57,42.78 129.59,42.8 CB5.1 CB6.1 128.88,44.09 128.94,44.14 R60471.2 128.41,44.55 v2(127.94,45.03)
TPM_GP68: length 97.8
  TOP w0.102: U9.6 128.92,39.19 129.87,38.24 130.96,38.24 133.81,35.4 v2(133.81,34) 133.61,33.8 132.92,33.8 v1(132.74,33.62)
  IN2 w0.102: v1(159.39,80.51) 160.24,81.36 164.81,81.36 168.05,78.12 168.05,70.91 166.32,69.18 166.32,59.82 163.56,57.06 163.56,53.79 164.39,52.96 164.39,44.01 162.76,42.38 v1(162.76,41.6)
  IN3 w0.102: v1(132.74,33.62) 133.53,34.41 136.24,34.41 137.72,35.88 152.1,35.88 153.48,34.5 156.24,34.5 162.76,41.02 v1(162.76,41.6)
  BOTTOM w0.102: R144.2 160.11,80.51 v1(159.39,80.51)
TS1#: length 45
  TOP w0.102: PQ10.5 139.5,40.05 PC54.1 140.41,40.49 140.42,40.5 PR67.2 140.77,40.71 140.29,41.19 v1(140.16,41.19) 140.49,41.52 v2(140.95,41.52)
  IN3 w0.102: v1(140.16,41.19) 140.5,41.19 141.4,42.1 141.4,43.1 141.8,43.49 142.16,43.49 142.41,43.73 142.41,46.11 141.01,47.52 140.54,47.52 139.57,48.49 139.57,48.95 138.61,49.91 138.61,51.86 138.27,52.2 138.27,54.66 136.55,56.38 135.77,56.38 133.87,58.28 131.24,58.28 129.97,59.55 129.97,64.94 129.13,65.78 129.13,67.36 128.63,67.86 127.77,67.86 126.5,69.13 v1(124.94,69.13)
  BOTTOM w0.102: v1(124.94,69.13) L11.2
TS1#_C: length 12.2
  TOP w0.102: v1(126.98,77.92) 126.98,75.72 T45.1
  BOTTOM w0.102: v1(126.98,77.92) 127.01,77.9 CON8.5 127.01,71.98 126.5,71.47 D20.1 125.87,70.77 C161.1 125.37,69.88 125.61,69.64 L11.1
USB3_RX_N2_OUT: length 57.8
  TOP w0.102: v2(42.84,84.7) 42.55,84.7 ; 42.55,84.7 42.55,86.31 41.77,87.09 38.94,87.09 38.55,86.7 36.13,86.7 35.71,86.28 U14.20 ; 42.55,84.7 42.55,84.25 42.79,84.01 v1(42.79,83.18)
  IN1 w0.127: v1(42.79,83.18) 42.62,83.34 42.62,83.36 42.62,83.65 42.38,83.89 41.02,83.89 40.62,83.48 37.21,83.48 36.43,84.27 33.83,84.27 31.57,86.53 30.77,86.53 30.21,85.97 30.21,85.21 27.77,82.77 23.81,82.77 22.89,81.86 20.85,81.86 17.53,78.53 15.68,78.53 14.77,77.61 11.74,77.61 10.67,76.55 5.95,76.55 5.74,76.75 5.41,76.75 v1(5.23,76.93)
  BOTTOM w0.102: CON10.55 4.92,77.24 v1(5.23,76.93)
USB3_RX_N3_OUT: length 32.9
  TOP w0.102: v1(27.64,86.57) 27.64,87.67 27.36,87.95 25.12,87.95 24.83,87.66 U13.20
  IN1 w0.127: v1(27.64,86.57) 27.54,86.46 27.54,85.77 26.08,84.32 23.17,84.32 22.48,83.63 19.86,83.63 19.48,83.25 19.48,82.97 17.38,80.87 11.38,80.87 9.91,79.39 7.7,79.39 6.81,78.5 v1(5.89,78.5)
  BOTTOM w0.102: v1(5.89,78.5) 5.49,78.91 5.04,78.91 4.88,78.74 CON10.52
USB3_RX_P2_OUT: length 57.7
  TOP w0.102: 38,86.49 36.22,86.49 35.92,86.19 35.92,85.92 36.02,85.82 36.15,85.82 36.21,85.75 U14.19 ; 38,86.49 38.63,86.49 39.02,86.89 41.68,86.89 42.34,86.22 42.34,84.17 42.58,83.93 42.58,83.75 42.5,83.66 42.04,83.66 41.91,83.53 41.91,83.41 v1(42.15,83.18) ; 38,86.49 v2(38,86.2)
  IN1 w0.127: v1(5.26,76.27) 5.51,76.52 5.65,76.52 5.85,76.32 10.76,76.32 11.83,77.39 14.86,77.39 15.77,78.3 17.62,78.3 20.95,81.63 22.99,81.63 23.9,82.54 27.87,82.54 30.44,85.11 30.44,85.88 30.86,86.3 31.47,86.3 33.73,84.04 36.33,84.04 37.12,83.25 40.71,83.25 41.12,83.66 42.29,83.66 42.39,83.55 42.39,83.42 v1(42.15,83.18)
  BOTTOM w0.102: CON10.56 4.78,76.74 v1(5.26,76.27)
USB3_RX_P3_OUT: length 32.8
  TOP w0.102: U13.19 25.33,87.28 25.27,87.35 25.1,87.35 25.04,87.41 25.04,87.58 25.21,87.75 27.27,87.75 27.43,87.59 27.43,86.96 27.36,86.89 27.05,86.89 26.98,86.81 v1(26.98,86.56)
  IN1 w0.127: v1(5.26,78.48) 5.26,78.53 5.67,78.94 6.1,78.94 6.3,78.73 6.71,78.73 7.6,79.62 9.81,79.62 11.29,81.09 17.28,81.09 19.25,83.07 19.25,83.35 19.77,83.86 22.39,83.86 23.07,84.55 25.99,84.55 27.31,85.87 27.31,86.22 v1(26.98,86.56)
  BOTTOM w0.102: v1(5.26,78.48) 5.26,78.33 5.18,78.24 CON10.53
USB3_RXN0: length 37.9
  TOP w0.102: SC23.1 36.09,78.9 36.09,78.63 v1(35.56,78.1)
  IN1 w0.127: v1(35.56,78.1) 35.84,77.82 35.84,77.61 35.67,77.44 33.07,77.44 32.54,77.96 27.67,77.96 25.81,76.09 25.81,72.4 24.9,71.49 22.28,71.49 21.59,70.8 21.59,69.01 21.85,68.76 21.85,67.07 21.35,66.58 21.35,65.79 21.69,65.45 21.69,62.21 22.06,61.84 22.06,58.79 22.46,58.39 23.13,58.39 24.02,57.5 24.02,57.26 v1(24.15,57.13)
  BOTTOM w0.089: U1.G20 24.43,56.85 v1(24.15,57.13)
USB3_RXN0_IN: length 1.8
  TOP w0.102: U14.11 35.71,81.24 35.87,81.08 35.87,80.72 36.11,80.49 36.11,80.38 SC23.2
USB3_RXN1: length 30.6
  TOP w0.102: v1(24.75,77.57) 25.06,77.26 25.37,77.26 25.54,77.43 25.54,78.39 25.12,78.8 25.12,79.27 ; 25.12,79.27 25.12,80.2 SC17.2 ; 25.12,79.27 v2(24.83,79.27)
  IN1 w0.127: v1(22.77,57.06) 22.56,57.27 22.49,57.27 21.53,58.23 21.53,61.15 21.06,61.62 21.06,64.39 20.4,65.05 20.4,70.88 21.88,72.36 23.81,72.36 24.23,72.78 24.23,73.17 23.47,73.93 23.47,74.77 24,75.3 24,76.82 v1(24.75,77.57)
  BOTTOM w0.102: v1(22.77,57.06) 23.13,57.43 U1.E18
USB3_RXN1_IN: length 1.9
  TOP w0.102: U13.11 24.83,82.86 25.01,82.69 25.01,81.78 SC17.1
USB3_RXP0: length 37.9
  TOP w0.102: SC24.1 36.3,78.87 36.3,78.18 v1(36.23,78.11)
  IN1 w0.127: v1(36.23,78.11) 36.07,77.95 36.07,77.51 35.76,77.21 32.97,77.21 32.45,77.73 27.77,77.73 26.04,76 26.04,72.31 25,71.26 22.38,71.26 21.82,70.71 21.82,69.11 22.06,68.86 22.06,66.98 21.57,66.49 21.57,65.88 21.91,65.54 21.91,62.3 22.28,61.93 22.28,58.88 22.55,58.61 23.22,58.61 24.17,57.66 24.25,57.66 24.76,57.16 v1(24.78,57.16)
  BOTTOM w0.089: U1.H20 25.08,56.85 v1(24.78,57.16)
USB3_RXP0_IN: length 1.8
  TOP w0.102: U14.12 36.21,81.3 36.08,81.16 36.08,80.81 36.31,80.57 36.31,80.39 SC24.2
USB3_RXP1: length 30.7
  TOP w0.102: v1(24.74,76.9) 24.9,77.06 25.45,77.06 25.74,77.34 25.74,77.87 ; SC18.2 25.33,80.34 25.33,78.88 25.74,78.47 25.74,77.87 ; 25.74,77.87 v2(26.03,77.87)
  IN1 w0.127: v1(24.74,76.9) 24.41,76.9 24.23,76.73 24.23,75.21 23.7,74.67 23.7,74.03 24.46,73.26 24.46,72.69 23.9,72.13 21.97,72.13 20.63,70.78 20.63,70.53 20.61,70.51 20.61,65.14 21.27,64.48 21.27,61.71 21.74,61.24 21.74,58.32 22.56,57.5 23.09,57.5 v1(23.52,57.07)
  BOTTOM w0.089: v1(23.52,57.07) 23.52,57.32 U1.F18
USB3_RXP1_IN: length 1.9
  TOP w0.102: SC18.1 25.22,81.86 25.22,82.63 25.33,82.75 U13.12
USB3_TX_N2_OUT: length 33.3
  TOP w0.102: SC20.2 30.19,86.24 30.02,86.4 v1(30.02,86.78)
  IN1 w0.127: v4(6.3,77.12) 6.3,77.49 6.45,77.64 7.41,77.64 7.93,78.16 10.17,78.16 12.02,80 17.76,80 20.28,82.52 22.66,82.52 23.54,83.41 27.2,83.41 29.56,85.76 29.56,86.31 v1(30.02,86.78)
  BOTTOM w0.102: CON10.59 4.95,75.24 5.06,75.35 5.06,75.46 5.14,75.54 5.53,75.54 6.02,76.03 6.02,77.03 6.11,77.12 v4(6.3,77.12)
USB3_TX_N3_OUT: length 16
  TOP w0.102: 10.49,79.77 9.35,79.77 8.38,78.81 6.29,78.81 5.61,79.49 5.61,79.75 v1(5.31,80.05) ; 10.49,79.77 11.38,79.77 13.06,81.45 13.06,82.61 14.34,83.89 14.92,83.89 15.15,83.66 15.15,83.41 15.28,83.28 SC14.2 ; 10.49,79.77 v2(10.49,79.48)
  BOTTOM w0.102: v1(5.31,80.05) 5.13,80.05 4.94,80.24 CON10.49
USB3_TX_P2_OUT: length 33.2
  TOP w0.102: SC22.2 30.46,87.06 30.3,87.22 29.65,87.22 v4(29.23,86.79)
  IN1 w0.127: v1(6.06,77.87) 7.31,77.87 7.83,78.39 10.08,78.39 11.92,80.23 17.66,80.23 20.18,82.75 22.57,82.75 23.45,83.63 27.11,83.63 29.33,85.85 29.33,86.37 29.23,86.46 v4(29.23,86.79)
  BOTTOM w0.102: CON10.58 5.45,75.74 5.82,76.12 5.82,77.23 6.06,77.47 v1(6.06,77.87)
USB3_TX_P3_OUT: length 16
  TOP w0.102: 7.55,79.01 6.38,79.01 5.82,79.57 5.82,79.93 v1(5.95,80.05) ; 7.55,79.01 8.3,79.01 9.26,79.98 11.3,79.98 12.85,81.53 12.85,82.69 14.25,84.09 SC16.2 ; 7.55,79.01 v2(7.55,79.3)
  BOTTOM w0.102: v1(5.95,80.05) 5.49,79.6 5.13,79.6 4.98,79.74 CON10.50
USB3_TXN0: length 51.1
  TOP w0.102: SC19.2 34.16,79.04 34.16,78.69 33.98,78.5 v1(33.76,78.5)
  IN1 w0.127: v1(19.66,48.25) 19.71,48.2 20.27,47.64 21.92,47.64 22.43,48.15 22.43,54.08 21.85,54.66 21.85,56.13 21.86,56.14 21.86,57.03 20.97,57.92 20.97,60.49 20.26,61.2 20.26,63.91 19.61,64.56 19.61,69.41 19.28,69.74 19.28,74.48 21.62,76.83 22.51,76.83 23.92,78.24 26.71,78.24 27.3,78.82 32.92,78.82 33.4,78.35 33.6,78.35 v1(33.76,78.5)
  BOTTOM w0.089: U1.C33 21.47,47.89 21.43,47.89 21.32,47.78 20.26,47.78 20.07,47.97 19.94,47.97 v1(19.66,48.25)
USB3_TXN0_IN: length 1.6
  TOP w0.102: SC19.1 34.28,80.64 34.28,81.05 34.21,81.12 U14.8
USB3_TXN0_OUT_C: length 5.4
  TOP w0.102: 32.46,86.55 32.97,86.55 33.45,87.04 34.18,87.04 34.36,86.86 34.36,86.47 34.51,86.32 34.51,86.01 34.44,85.95 34.29,85.95 34.21,85.87 U14.23 ; 32.46,86.55 31.81,86.55 SC20.1 ; 32.46,86.55 v2(32.46,86.26)
USB3_TXN1: length 42.7
  TOP w0.102: 20.04,78.4 20.04,76.5 18.43,74.89 18.43,73.47 18.28,73.32 18.19,73.32 v1(17.93,73.58) ; 20.04,78.4 v2(19.75,78.4) ; 20.04,78.4 20.04,78.87 21.16,79.98 22.84,79.98 22.93,80.07 SC13.1
  IN1 w0.127: v1(19.58,49.6) 19.74,49.45 20.86,49.45 21.28,49.86 21.28,52.21 20.45,53.03 20.45,56.13 20.46,56.13 20.46,59.87 19.67,60.66 18.47,60.66 17.86,61.28 17.86,62.86 18.2,63.2 18.2,64.45 17.69,64.97 17.69,70.17 16.64,71.21 16.64,72.92 17.04,73.32 17.68,73.32 v1(17.93,73.58)
  BOTTOM w0.102: v1(19.58,49.6) 19.61,49.6 20.32,48.89 20.32,48.82 20.72,48.42 20.72,48.42 21.06,48.08 U1.B33
USB3_TXN1_IN: length 2
  TOP w0.102: U13.8 23.33,82.77 23.48,82.62 23.48,82.41 23.27,82.2 23.27,81.83 SC13.2
USB3_TXN1_OUT_C: length 11.2
  TOP w0.102: SC14.1 16.83,83.66 17,83.66 17.56,84.22 18.7,84.22 19.06,84.59 19.06,86.67 20.14,87.75 23.44,87.75 23.63,87.55 23.63,87.45 23.57,87.39 23.42,87.39 23.33,87.31 U13.23
USB3_TXP0: length 51.1
  TOP w0.102: v1(34.37,78.3) 34.37,79.02 SC21.2
  IN1 w0.127: v1(34.37,78.3) 34.14,78.07 33.35,78.07 32.83,78.6 27.39,78.6 26.8,78.01 24.01,78.01 22.6,76.6 21.72,76.6 19.51,74.39 19.51,69.82 19.83,69.5 19.83,64.65 20.47,64 20.47,61.29 21.19,60.58 21.19,58.01 22.07,57.12 22.07,54.75 22.66,54.17 22.66,48.06 22.01,47.41 20.18,47.41 20,47.59 v1(19.66,47.59)
  BOTTOM w0.089: U1.B34 21.4,47.6 20.19,47.6 19.99,47.79 19.86,47.79 v1(19.66,47.59)
USB3_TXP0_IN: length 1.5
  TOP w0.102: U14.9 34.71,81.16 34.49,80.93 34.49,80.42 SC21.1
USB3_TXP0_OUT_C: length 5.6
  TOP w0.102: 33.78,87.24 33.37,87.24 32.88,86.75 31.8,86.75 SC22.1 ; 33.78,87.24 v2(33.78,87.53) ; 33.78,87.24 34.27,87.24 34.57,86.94 34.57,86.55 34.71,86.4 U14.22
USB3_TXP1: length 42.6
  TOP w0.102: 20.25,76.83 v2(20.54,76.83) ; 20.25,76.83 20.25,78.78 21.24,79.78 22.92,79.78 23.13,79.99 23.13,80.15 23.21,80.23 23.7,80.23 23.77,80.3 SC15.1 ; 20.25,76.83 20.25,76.42 18.63,74.81 18.63,73.39 18.37,73.12 18.11,73.12 v1(17.93,72.94)
  IN1 w0.127: v1(17.93,72.94) 17.78,73.09 17.14,73.09 16.87,72.82 16.87,71.31 17.92,70.26 17.92,65.06 18.43,64.55 18.43,63.11 18.09,62.76 18.09,61.35 18.56,60.88 19.76,60.88 20.68,59.96 20.68,56.13 20.68,56.13 20.68,53.13 21.51,52.31 21.51,49.77 20.96,49.22 19.95,49.22 v1(19.66,48.93)
  BOTTOM w0.102: v1(19.66,48.93) 19.93,48.93 20.51,48.34 U1.A33
USB3_TXP1_IN: length 2
  TOP w0.102: SC15.2 23.47,81.78 23.47,82.11 23.69,82.32 23.69,82.62 23.83,82.77 U13.9
USB3_TXP1_OUT_C: length 11.3
  TOP w0.102: SC16.1 16.68,83.86 16.92,83.86 17.48,84.42 18.61,84.42 18.86,84.67 18.86,86.75 20.06,87.95 23.52,87.95 23.83,87.64 U13.22
USB_BIAS: length 7.3
  TOP w0.089: v1(36.98,60.95) 37.39,61.36 v2(37.82,61.36) 38.04,61.58 41.06,61.58 41.17,61.69 R108.1
  BOTTOM w0.089: v1(36.98,60.95) 36.98,61 36.65,61.34 U1.AJ11 U1.AJ10
USB_PN0: length 76.7
  IN1 w0.089: 42.84,65.69 42.82,65.69 41.73,64.61 41.4,64.61 40.31,63.52 39.65,63.52 v1(39.22,63.09)
  IN1 w0.127: 42.84,65.69 45.53,68.38 45.53,69.5 45.85,69.82 45.85,70.96 46.45,71.55 46.45,73.99 48.03,75.58 49.22,75.58 49.66,76.02 49.66,78.31 50.4,79.04 50.4,82.46 49.93,82.92 46.76,82.92 45.16,84.52 45.16,85.74 44.65,86.25 38.88,86.25 38.04,87.09 34.74,87.09 32.85,88.98 24.58,88.98 22.61,87.01 21.95,87.01 21.17,86.22 20.58,86.22 20.12,86.68 19.21,86.68 17.53,85.01 16.8,85.01 15.93,84.14 12.27,84.14 11.83,83.7 10.47,83.7 10.09,84.09 10.09,85.24 v1(10.29,85.45)
  BOTTOM w0.089: U1.AN8 39.22,63.19 v1(39.22,63.09)
  BOTTOM w0.102: v1(10.29,85.45) 10.08,85.66 10.08,86.21 9.71,86.58 9.27,86.58 9.11,86.74 CON10.6
USB_PN1: length 82.3
  IN1 w0.089: v1(39.56,64.49) 39.56,64.19 39.45,64.08 36.68,64.08 36.55,64.2 36.55,66.95 36.86,67.25 39.7,67.25 40.61,66.35 42.66,66.35 44.83,68.52 44.83,69.41 44.53,69.71 44.53,70.49 44.55,70.52 44.55,70.53
  IN1 w0.127: v4(6.76,85.85) 7.11,85.49 7.11,84.99 9.14,82.96 12.59,82.96 13.03,83.41 16.24,83.41 17.05,84.22 17.81,84.22 19.08,85.49 21.64,85.49 22.33,86.17 23.75,86.17 25.75,88.17 32.6,88.17 33,87.78 33,87.41 34.21,86.2 37.82,86.2 38.5,85.51 43.07,85.51 46.58,82.01 48.71,82.01 49.29,81.43 49.29,79.18 47.83,77.72 47.83,76.47 45.71,74.35 45.71,72.55 44.55,71.4 44.55,70.53
  BOTTOM w0.102: v1(39.56,64.49) 39.56,64.13 39.68,64 39.68,64 39.82,64 U1.AR7 ; CON10.8 6.86,85.74 v4(6.76,85.85)
USB_PN2: length 140.2
  IN3 w0.089: v1(40.53,63.1) 40.3,63.33 40.3,63.71 40.3,63.79 40.4,63.9 40.64,63.9 41.43,64.69 42.29,64.69 44.11,66.5 45.09,66.5 45.18,66.5 45.22,66.54 45.24,66.54 45.25,66.55
  IN3 w0.114: v1(162.56,79.77) 161.8,79.01 159.19,79.01 158.63,79.57 153.54,79.57 152.07,78.1 147.19,78.1 146.61,77.51 140.79,77.51 140.36,77.94 136.4,77.94 135.84,78.5 115.6,78.5 115.25,78.85 109.19,78.85 109.04,78.71 100.05,78.71 97.84,76.5 93.12,76.5 92.64,76.97 89.38,76.97 89.15,76.74 83.45,76.74 82.89,77.3 78.04,77.3 76.4,75.66 68.27,75.66 66.39,77.54 63.62,77.54 63.4,77.32 59.46,77.32 56.74,74.59 54.15,74.59 52.22,72.66 51.17,72.66 50.75,72.24 50.75,71.96 50.75,71.77 50.24,71.26 50.24,71.1 47.46,68.32 47.02,68.32 45.25,66.55
  BOTTOM w0.089: v1(40.53,63.1) 40.54,63.11 40.49,63.16 40.22,63.44 U1.AR8
  BOTTOM w0.102: 162.16,80.71 v2(161.86,80.71) ; 162.16,80.71 162.16,80.33 162.56,79.93 v1(162.56,79.77) ; 162.16,80.71 162.16,83.07 161.57,83.65 161.57,84.07 161.28,84.36 RN6.3
USB_PN3: length 49.4
  IN1 w0.089: 43.13,65.19 43.12,65.19 43.1,65.19 43.06,65.15 43.06,65.15 42.8,64.89 42.8,63.8 42.24,63.24 41.53,63.24 40.97,62.68 40.97,62.5 40.61,62.14 39.97,62.14 v1(39.57,62.54)
  IN1 w0.127: 43.13,65.19 46.2,68.27 46.2,69.19 47.09,70.08 47.09,70.81 47.18,70.9 47.18,73.08 47.42,73.32 48.49,73.32 49.13,73.96 49.13,74.32 50.8,76 50.8,78.15 51.59,78.94 51.59,82.33 47.57,86.35 45.64,86.35 45,86.99 39.29,86.99 37.28,88.99 36.04,88.99 35.7,88.65 35.7,87.75 v4(35.58,87.64)
  BOTTOM w0.089: v1(39.57,62.54) 39.89,62.22 U1.AR10
  BOTTOM w0.102: L6.3 35.73,88.61 35.83,88.51 35.83,87.88 v4(35.58,87.64)
USB_PN4: length 174
  IN3 w0.114: v1(160.06,79.86) 160.06,79.87 160.19,80 160.19,80.4 159.64,80.94 146.91,80.94 144.2,78.24 141.09,78.24 139.45,79.87 116.33,79.87 116.03,79.58 108.8,79.58 108.66,79.44 99.76,79.44 97.68,77.36 93.45,77.36 93.12,77.7 88.93,77.7 88.7,77.46 83.75,77.46 83.19,78.02 77.24,78.02 76,76.78 68.17,76.78 66.48,78.47 61.54,78.47 61.12,78.04 59.16,78.04 57.01,75.89 54.43,75.89 53.1,74.57 52.53,74.57 51.36,73.4 50.88,73.4 50.12,72.64 47.71,72.64 46.06,70.99 45.19,70.99 44.84,71.34 41.43,71.34 41.15,71.06 36.6,71.06 35.82,70.27 35.82,68.17 34.98,67.33 34.98,60.16 35.43,59.71 36.09,59.71 36.37,59.99 37.68,59.99 v1(38.51,59.16)
  BOTTOM w0.089: v1(38.51,59.16) 38.61,59.26 38.61,59.58 38.52,59.66 U1.AM15
  BOTTOM w0.102: 168.53,77.21 169.83,77.21 171.87,79.25 172.22,79.25 173.51,80.54 173.51,81.7 174.2,82.39 174.94,82.39 176.07,83.52 176.07,85.41 176.63,85.97 176.92,85.97 177.05,85.84 177.05,85.67 176.94,85.56 176.81,85.56 176.75,85.5 CON11.1 ; 168.53,77.21 166.4,77.21 166.19,77.41 162.54,77.41 160.44,79.51 160.42,79.51 160.41,79.52 160.06,79.87 v1(160.06,79.86) ; 168.53,77.21 v2(168.53,76.92)
USB_PN5: length 143.7
  IN3 w0.089: v1(37.54,60.69) 37.69,60.84 37.69,61.25 38.31,61.87 42.07,61.87 43.33,63.13 43.33,65.04 44.36,66.07 45.68,66.07 45.77,66.07 45.79,66.09 45.81,66.09 45.82,66.1
  IN3 w0.114: v1(160.07,69.71) 159.82,69.97 159.82,70.45 159.54,70.73 157.6,70.73 157.3,71.03 157.3,71.37 v4(157.5,71.57) 157.3,71.77 157.3,73.83 156.95,74.19 155.96,74.19 155.17,73.39 153.69,73.39 153.55,73.53 141.68,73.53 141.31,73.9 117.79,73.9 117.26,73.37 113.58,73.37 113.06,73.9 110.49,73.9 110.15,74.24 100.99,74.24 98.7,71.95 96.35,71.95 94.16,69.77 92.72,69.77 91.63,68.67 90.83,68.67 90.12,69.38 88.49,69.38 85.31,72.56 79.12,72.56 76.73,74.95 68.28,74.95 66.19,77.03 63.82,77.03 63.61,76.82 59.67,76.82 56.93,74.08 54.34,74.08 51.01,70.75 50.83,70.57 50.68,70.42 50.68,70.39 48.18,67.89 47.57,67.89 45.82,66.14 45.82,66.1
  BOTTOM w0.089: U1.AM13 37.8,60.37 37.65,60.52 37.54,60.63 v1(37.54,60.69)
  BOTTOM w0.102: U20.37 159.93,69.57 v1(160.07,69.71)
USB_PN6: length 202.3
  IN1 w0.089: v1(39.24,61.18) 39.7,61.64 42.3,61.64 42.9,62.24 42.9,63.01 43.33,63.44 43.33,64.56 44.11,65.34 44.11,65.39 44.13,65.41
  IN1 w0.127: v1(157.35,43.86) 157.35,43.27 157.35,43.27 157.35,43.27 157.35,42.82 157.1,42.56 154.58,42.56 151.07,39.06 142.29,39.06 141.78,38.55 140.13,36.9 138.53,36.9 136.14,34.5 136.14,32.5 132.56,28.92 107.6,28.92 106.97,29.56 101.8,29.56 98.5,32.86 98.5,35.4 91.37,42.54 91.37,48.66 92.61,49.9 92.61,68.55 93.19,69.13 93.19,70.35 91.18,72.36 89.94,72.36 88.5,73.8 88.5,74.97 88.09,75.38 82.77,75.38 81.43,76.73 76.4,76.73 75.69,76.01 72.03,76.01 71.01,75 64.09,75 62.9,73.81 58.93,73.81 58.68,74.06 55.75,74.06 55.14,73.45 54.69,73.45 54.05,72.81 50.11,72.81 49.11,71.82 49.11,70.88 46.84,68.61 46.84,68.12 44.13,65.41
  BOTTOM w0.102: U1.AP11 39.57,61.5 v1(39.24,61.18) ; CONWIFI.5 179.79,42.85 179.64,42.71 179.54,42.71 179.07,43.17 179.07,43.58 178.26,44.39 167.53,44.39 167.1,43.96 164.53,43.96 163.21,42.64 157.56,42.64 157.35,42.84 v1(157.35,43.86)
USB_PN7: length 109.7
  IN1 w0.089: 49.53,70.53 49.52,70.51 49.52,70.48 48.29,69.25 48.29,68.87 44.83,65.42 44.83,64.76 43.61,63.54 43.61,62.55 42.74,61.67 42.74,61.06 42.32,60.65 v1(39.59,60.65)
  IN1 w0.127: 49.53,70.53 50.01,71.01 50.01,71.54 50.29,71.82 50.9,71.82 51.03,71.69 51.04,71.68 51.63,71.68 52.26,72.31 54.36,72.31 54.75,72.69 55.3,72.69 56.12,73.5 58.27,73.5 58.47,73.3 63.11,73.3 63.43,73.63 66.63,73.63 67.36,74.36 84.46,74.36 84.67,74.16 87.4,74.16 89.71,71.85 90.97,71.85 92.61,70.22 92.61,69.34 92.08,68.81 92.08,52.42 90.58,50.93 90.58,42.61 93.22,39.96 93.22,38.43 92.6,37.81 92.08,37.81 v1(91.8,37.53)
  BOTTOM w0.089: v1(39.59,60.65) 39.64,60.6 39.64,60.48 39.75,60.37 U1.AR13
  BOTTOM w0.102: 93.63,36.31 93.63,35.3 94.51,34.41 94.51,30.78 94.81,30.48 95.09,30.48 95.24,30.33 CONSATA.9 ; 93.63,36.31 93.63,37.4 93.29,37.74 92,37.74 v1(91.8,37.53) ; 93.63,36.31 v2(93.33,36.31)
USB_PP0: length 76.7
  IN1 w0.089: 42.69,65.85 42.68,65.83 42.68,65.8 42.65,65.78 42.65,65.77 41.66,64.79 41.33,64.79 40.24,63.7 39.18,63.7 v1(38.59,63.1)
  IN1 w0.127: v1(9.62,85.45) 9.86,85.21 9.86,83.99 10.38,83.47 11.92,83.47 12.36,83.91 16.03,83.91 16.89,84.78 17.63,84.78 19.31,86.45 20.02,86.45 20.48,86 21.26,86 22.05,86.78 22.71,86.78 24.67,88.75 32.75,88.75 34.64,86.86 37.95,86.86 38.79,86.02 44.55,86.02 44.93,85.64 44.93,84.43 46.67,82.69 49.84,82.69 50.17,82.36 50.17,79.14 49.43,78.4 49.43,76.12 49.13,75.81 47.94,75.81 46.22,74.09 46.22,71.65 45.62,71.05 45.62,69.89 45.32,69.59 45.32,68.49 45.31,68.48 45.31,68.47 42.69,65.85
  BOTTOM w0.102: v1(9.62,85.45) 9.88,85.7 9.88,86.13 9.63,86.38 9.27,86.38 9.14,86.24 CON10.7 ; U1.AM8 38.27,63.43 v1(38.59,63.1)
USB_PP1: length 82.2
  IN1 w0.089: v1(40.21,64.51) 39.6,63.9 36.61,63.9 36.37,64.13 36.37,67.02 36.78,67.43 39.78,67.43 40.68,66.53 42.58,66.53 44.65,68.6 44.65,69.34 44.35,69.64 44.35,70.49 44.32,70.52 44.32,70.53
  IN1 w0.127: v1(6.68,85.09) 6.69,85.09 9.05,82.73 12.68,82.73 13.13,83.18 16.33,83.18 17.15,83.99 17.91,83.99 19.18,85.26 21.74,85.26 22.42,85.95 23.85,85.95 25.84,87.94 32.51,87.94 32.77,87.68 32.77,87.32 34.11,85.97 37.72,85.97 38.41,85.29 42.98,85.29 46.48,81.78 48.62,81.78 49.06,81.34 49.06,79.27 47.6,77.81 47.6,76.57 45.48,74.45 45.48,72.65 44.32,71.49 44.32,70.53
  BOTTOM w0.102: v1(40.21,64.51) 40.54,64.18 U1.AT7 ; CON10.9 8.2,85.25 6.83,85.25 6.68,85.1 v1(6.68,85.09)
USB_PP2: length 139.8
  IN3 w0.089: v1(39.9,63.09) 40.12,63.31 40.12,63.7 40.12,63.71 40.12,63.87 40.21,63.96 40.33,64.08 40.57,64.08 41.36,64.86 42.22,64.86 44.03,66.68 44.95,66.68 45.09,66.68 45.1,66.69
  IN3 w0.114: v4(162.58,80.54) 162.13,80.1 162.13,79.66 161.7,79.24 159.28,79.24 158.73,79.8 153.45,79.8 151.98,78.33 147.1,78.33 146.52,77.74 140.88,77.74 140.45,78.17 136.49,78.17 135.94,78.73 115.69,78.73 115.34,79.08 109.1,79.08 108.95,78.94 99.95,78.94 97.74,76.73 93.21,76.73 92.74,77.2 89.29,77.2 89.05,76.97 83.54,76.97 82.99,77.52 77.94,77.52 76.3,75.89 68.36,75.89 66.48,77.77 63.53,77.77 63.31,77.54 59.37,77.54 56.64,74.82 54.06,74.82 52.13,72.89 51.08,72.89 50.52,72.34 50.52,71.87 50.01,71.36 50.01,71.2 49.94,71.12 47.34,68.52 46.93,68.52 45.1,66.69
  BOTTOM w0.089: U1.AP8 39.57,63.42 39.87,63.12 v1(39.9,63.09)
  BOTTOM w0.102: v4(162.58,80.54) 162.36,80.76 162.36,83.15 161.77,83.74 161.77,83.96 162.08,84.27 RN6.1
USB_PP3: length 49.4
  IN1 w0.089: 42.98,65.35 42.98,65.32 42.62,64.97 42.62,63.87 42.17,63.42 41.45,63.42 40.58,62.54 v1(40.22,62.54)
  IN1 w0.127: v1(36.36,87.64) 36.67,87.64 36.83,87.8 36.83,88 36.65,88.18 36.04,88.18 35.93,88.3 35.93,88.55 36.14,88.76 37.19,88.76 39.19,86.76 44.91,86.76 45.54,86.12 47.47,86.12 51.36,82.24 51.36,79.03 50.57,78.24 50.57,76.09 48.9,74.41 48.9,74.05 48.4,73.55 47.33,73.55 46.95,73.18 46.95,70.99 46.86,70.9 46.86,70.16 45.99,69.28 45.99,68.36 42.98,65.35
  BOTTOM w0.089: U1.AT10 40.31,62.15 40.22,62.24 v1(40.22,62.54)
  BOTTOM w0.102: v1(36.36,87.64) 36.03,87.96 36.03,88.6 35.81,88.82 35.56,88.82 35.43,88.94 35.43,89.3 35.27,89.46 L6.2
USB_PP4: length 174
  IN3 w0.114: v1(160.71,79.87) 160.42,80.17 160.42,80.49 159.74,81.17 146.81,81.17 144.11,78.47 141.18,78.47 139.55,80.1 116.23,80.1 115.93,79.81 108.7,79.81 108.57,79.67 99.67,79.67 97.58,77.59 93.55,77.59 93.21,77.93 88.84,77.93 88.6,77.69 83.84,77.69 83.29,78.25 77.15,78.25 75.9,77 68.27,77 66.58,78.69 61.45,78.69 61.02,78.27 59.07,78.27 56.92,76.12 54.33,76.12 53.01,74.79 52.43,74.79 51.27,73.63 50.78,73.63 50.03,72.87 47.61,72.87 45.97,71.22 45.28,71.22 44.94,71.57 41.33,71.57 41.05,71.29 36.51,71.29 35.59,70.37 35.59,68.27 34.75,67.43 34.75,60.06 35.33,59.48 36.19,59.48 36.47,59.76 37.59,59.76 37.87,59.47 v1(37.87,59.16)
  BOTTOM w0.089: v1(37.87,59.16) 37.61,59.42 U1.AL15
  BOTTOM w0.102: 164.95,77.61 v2(164.95,77.91) ; 164.95,77.61 162.63,77.61 160.71,79.53 v1(160.71,79.87) ; 164.95,77.61 166.28,77.61 166.48,77.41 169.74,77.41 171.79,79.46 172.13,79.46 173.31,80.63 173.31,81.78 174.12,82.59 174.86,82.59 175.87,83.61 175.87,85.5 176.55,86.17 177,86.17 177.25,85.92 CON11.2
USB_PP5: length 145.2
  TOP w0.102: R431.1 160.1,68.92 v1(159.31,69.71)
  IN3 w0.089: v1(38.26,60.62) 38.16,60.62 37.87,60.91 37.87,61.18 38.38,61.69 42.14,61.69 43.51,63.06 43.51,64.97 44.44,65.89 45.69,65.89 45.77,65.89 45.84,65.89 45.86,65.91 45.92,65.91 45.93,65.92
  IN3 w0.114: 45.93,65.92 47.69,67.68 48.27,67.68 54.44,73.86 57.02,73.86 59.76,76.59 63.7,76.59 63.91,76.8 66.1,76.8 68.18,74.72 76.64,74.72 79.03,72.33 85.22,72.33 88.39,69.16 90.03,69.16 90.74,68.44 91.72,68.44 92.81,69.54 94.26,69.54 96.44,71.72 98.8,71.72 101.08,74.01 110.06,74.01 110.4,73.67 112.96,73.67 113.49,73.14 117.36,73.14 117.88,73.67 141.21,73.67 141.58,73.3 153.45,73.3 153.6,73.16 155.26,73.16 156.06,73.96 156.85,73.96 157.08,73.73 157.08,73.39 v4(156.88,73.19) 157.08,73 157.08,70.93 157.51,70.5 159.44,70.5 159.59,70.36 159.59,69.99 v1(159.31,69.71)
  BOTTOM w0.089: v1(38.26,60.62) 38.26,60.19 38.34,60.11 38.48,60.11 U1.AN13
  BOTTOM w0.102: U20.38 159.43,68.87 159.72,69.16 159.72,69.29 v1(159.31,69.71)
USB_PP6: length 202.4
  IN1 w0.089: v1(38.61,61.18) 39.21,61.78 39.6,61.78 39.63,61.82 42.23,61.82 42.72,62.31 42.72,63.08 43.16,63.51 43.16,64.63 43.93,65.41 43.93,65.49 43.97,65.53 43.97,65.53 43.97,65.55 43.98,65.56
  IN1 w0.127: v1(156.87,43.43) 157.13,43.17 157.13,42.91 157.01,42.79 154.48,42.79 150.98,39.29 142.2,39.29 141.56,38.64 140.04,37.13 138.44,37.13 135.91,34.6 135.91,32.59 132.47,29.15 107.7,29.15 107.06,29.79 101.9,29.79 98.73,32.95 98.73,35.49 91.59,42.63 91.59,48.57 92.84,49.81 92.84,68.45 93.42,69.04 93.42,70.45 91.28,72.59 90.03,72.59 88.72,73.9 88.72,75.07 88.18,75.61 82.87,75.61 81.52,76.95 76.31,76.95 75.6,76.24 71.93,76.24 70.92,75.23 63.99,75.23 62.8,74.04 59.03,74.04 58.78,74.29 55.66,74.29 55.05,73.68 54.59,73.68 53.96,73.04 50.01,73.04 48.88,71.91 48.88,70.98 46.61,68.71 46.61,68.19 43.98,65.56
  BOTTOM w0.102: v1(38.61,61.18) 38.92,61.49 U1.AN11 ; CONWIFI.3 179.79,42.35 179.64,42.5 179.45,42.5 178.87,43.09 178.87,43.49 178.17,44.19 167.62,44.19 167.18,43.76 164.62,43.76 163.3,42.44 157.47,42.44 157.15,42.76 157.15,43.15 v1(156.87,43.43)
USB_PP7: length 109.8
  IN1 w0.089: 49.69,70.37 49.68,70.35 49.64,70.35 48.46,69.17 48.46,68.8 45.01,65.35 45.01,64.69 43.79,63.47 43.79,62.48 42.91,61.6 42.91,60.99 42.39,60.47 40.13,60.47 39.9,60.24 39.33,60.24 v1(38.93,60.64)
  IN1 w0.127: 49.69,70.37 50.24,70.92 50.24,71.45 50.39,71.59 50.8,71.59 50.87,71.52 50.94,71.45 51.04,71.45 51.13,71.45 51.73,71.45 52.35,72.08 54.46,72.08 54.84,72.46 55.4,72.46 56.21,73.27 58.17,73.27 58.37,73.07 63.2,73.07 63.53,73.4 66.72,73.4 67.46,74.13 84.37,74.13 84.57,73.93 87.31,73.93 89.61,71.63 90.88,71.63 92.38,70.12 92.38,69.44 91.85,68.9 91.85,52.52 90.35,51.02 90.35,42.51 92.99,39.87 92.99,38.52 92.51,38.04 91.95,38.04 v1(91.8,38.19)
  BOTTOM w0.089: U1.AP13 38.93,60.54 v1(38.93,60.64)
  BOTTOM w0.102: v1(91.8,38.19) 92.05,37.94 92.58,37.94 ; CONSATA.7 95.26,30.83 95.11,30.68 94.9,30.68 94.72,30.86 94.72,34.49 93.83,35.38 93.83,37.48 93.37,37.94 92.58,37.94 ; 92.58,37.94 v2(92.58,38.23)
USBP10+: length 6.2
  BOTTOM w0.102: L5.1 162.1,86.38 161.77,86.71 161.77,86.82 161.98,87.02 161.98,88 160.79,89.19 CON6.2
USBP10-: length 6.3
  BOTTOM w0.102: L5.4 161.25,86.39 161.57,86.71 161.57,86.91 161.77,87.11 161.77,87.92 160.71,88.99 159.59,88.99 159.44,88.83 159.44,88.54 159.29,88.39 CON6.3
V_DOWN: length 173.8
  TOP w0.102: v2(6.81,83) v1(6.07,83.74)
  IN1 w0.102: v1(108.46,78) 109.45,78.99 111.55,78.99 112.82,80.26 126.67,80.26 v1(127.59,79.34)
  IN2 w0.102: v1(6.07,83.74) 6.82,83.74 9.8,86.72 13.54,86.72 13.79,86.97 16.57,86.97 18.01,88.42 21.22,88.42 23.46,90.65 42.82,90.65 43.86,89.62 51.07,89.62 52.1,90.65 125.24,90.65 v1(127.48,88.41)
  BOTTOM w0.102: v1(108.46,78) 109.4,78.93 U10.88 115.54,78.93 115.82,78.65 115.82,76.92 116.09,76.64 116.35,76.64 116.82,76.17 116.82,75.74 116.28,75.2 116.28,74.01 R204.2 ; CON10.15 7.28,82.24 7.01,82.52 7.01,82.8 v1(6.07,83.74) ; v1(127.48,88.41) 127.95,87.94 127.95,79.71 v1(127.59,79.34)
V_LCD_C: length 4.7
  TOP w0.102: v2(175.87,33.77) 175.04,32.94 Q22.3
  TOP w0.254: R299.2 173.5,33.88 173.5,33.87 Q22.3
V_LCD_G: length 27.3
  TOP w0.102: v2(176.4,35.49) C146.1
  TOP w0.254: R296.2 169.61,15.32 170.23,15.94 v1(170.64,15.94) ; C146.1 174.18,36.21 R299.1 173.35,36.21 172.15,35.01 Q21.1 v1(172.03,34.26)
  IN1 w0.254: v1(172.03,34.26) 172.42,33.88 172.42,17.97 170.64,16.19 v1(170.64,15.94)
V_UP: length 164
  TOP w0.102: v1(111.22,77.84) 110.81,78.26 109.95,78.26 109.39,78.82 R200.2 ; v2(11.62,81.25) 11.62,81.97 11.28,82.31 D4.2 10.26,82.77 v1(9.69,82.2)
  IN1 w0.102: v1(126.87,79.34) 126.16,80.05 112.9,80.05 111.22,78.37 v1(111.22,77.84)
  IN2 w0.102: v1(126.82,88.38) 124.76,90.45 52.19,90.45 51.15,89.42 43.77,89.42 42.74,90.45 23.54,90.45 21.31,88.21 18.1,88.21 16.65,86.77 13.88,86.77 13.63,86.52 9.92,86.52 8.49,85.08 8.49,83.41 v1(9.69,82.2)
  BOTTOM w0.102: v1(9.69,82.2) 9.69,82.19 9.14,82.74 CON10.14 ; v1(126.87,79.34) 127.66,80.13 127.66,87.55 v1(126.82,88.38) ; v1(111.22,77.84) 111.92,78.53 U10.89
VB+: length 16.6
  TOP w0.508: T31.1 186.89,23.33 v1(186.26,23.97)
  BOTTOM w0.508: T30.1 182.45,18.38 183.22,19.15 CON4.1 184.92,19.46 184.92,19.81 185.59,20.48 C98.1 186.55,20.91 187.05,21.4 D9.2 187.05,23.18 v1(186.26,23.97) 186.26,25.86 ST8.1 187.97,27.57 Q6.3
VIBRATER_DET_CBL#: length 241
  IN2 w0.089: 27.46,70.93 27.26,70.74 27.26,68.21 28.64,66.83 28.64,64.59 v1(28.22,64.17)
  IN2 w0.102: v1(156.4,37.13) 156.4,38.48 152.02,42.86 152.02,62.17 146.81,67.38 146.81,74.4 145.37,75.85 142.6,75.85 141.66,76.79 138.98,76.79 135.35,80.41 127.69,80.41 127.42,80.14 121.49,80.14 120.93,79.59 120.93,79.22 120.43,78.72 113.91,78.72 113.63,79 109.68,79 108.95,79.72 108.95,79.79 108.09,80.66 107.83,80.66 107.62,80.88 102.27,80.88 102.06,80.67 99.75,80.67 98.95,79.86 94.67,79.86 94.44,80.09 92.91,80.09 92.6,80.4 88.87,80.4 88.44,80.83 86.08,80.83 85.52,81.39 83.48,81.39 83,80.9 77.97,80.9 76.37,82.5 69.78,82.5 69.45,82.17 67.71,82.17 65.72,80.18 61.4,80.18 60.58,81.01 55.04,81.01 54.62,81.43 49.68,81.43 48.66,80.41 46.46,80.41 46.07,80.8 45.25,80.8 44.39,79.95 41.08,79.95 40.52,79.38 38.33,79.38 37.92,79.79 37.3,79.79 37.11,79.6 33.9,79.6 32.64,78.34 31.71,78.34 30.58,77.21 30.58,75.81 29.52,74.74 29.52,72.99 27.46,70.93
  BOTTOM w0.089: v1(28.22,64.17) 28.57,64.52 U1.R6
  BOTTOM w0.102: CON4.3 186.52,17.5 184.35,15.33 R427.2 v2(182.7,15.33) 181.69,14.32 179.4,14.32 175.07,18.65 175.07,31.34 173.59,32.83 173.59,34.63 173,35.21 173,39.46 170.47,41.99 169.4,41.99 167.11,39.7 163.95,39.7 162.28,38.03 159.16,38.03 158.26,37.13 v1(156.4,37.13)
VIBRATOR_ON#: length 139.2
  TOP w0.102: v1(130.28,87.61) 130.28,88.23 v2(129.52,88.99) 128.06,90.45 98.08,90.45 96.67,89.04 v1(96.67,88.41)
  IN2 w0.102: v1(130.28,87.61) 130.91,88.24 149.49,88.24 151.49,86.25 v1(151.49,85.11)
  IN3 w0.102: v1(151.49,85.11) 151.49,84.68 152.13,84.03 157.63,84.03 159.18,82.48 164.05,82.48 168.33,78.21 168.33,73.03 167.69,72.39 167.69,49.27 169.43,47.53 169.43,44.8 170,44.22 v1(170,43.02)
  BOTTOM w0.102: Q7.2 181.31,31.34 181.05,31.59 175.11,31.59 173.79,32.91 173.79,34.71 173.21,35.3 173.21,39.54 170.79,41.96 170.79,42.23 v1(170,43.02) ; U10.31 97.96,87.73 97.77,87.93 97.15,87.93 v1(96.67,88.41)
VIBRATOR_ON_G#: length 4.2
  TOP w0.102: v2(182.58,26.64) v1(182.58,27.44)
  BOTTOM w0.102: Q6.1 C99.2 R236.2 v1(182.58,27.44) VR1.1
VIBRATOR_ON_R_G#: length 2.3
  TOP w0.102: v2(179.91,28.03) v1(180.66,28.03)
  BOTTOM w0.102: VR1.2 180.66,27.9 v1(180.66,28.03) Q7.6
VIBRATOR_ON_S: length 5.9
  TOP w0.102: v2(186.35,28.58) v1(186.35,29.34)
  BOTTOM w0.102: Q6.2 v1(186.35,29.34)
  BOTTOM w0.508: Q6.2 C97.1 HR48.2 R236.1 C99.1
VIDALERT#: length 29.7
  TOP w0.102: v2(12.04,11.98) 12.04,12.73 v1(12.16,12.84)
  IN1 w0.127: v1(12.16,12.84) 12.16,12.84 12.64,12.36 14.89,12.36 16.18,11.07 v1(23.52,11.07)
  BOTTOM w0.102: PR105.2 v1(12.16,12.84) ; v1(23.52,11.07) 24.41,11.07 25.02,11.67 25.02,12.74 29.95,17.67 29.95,20.55 29.72,20.78 29.72,21.34 29.41,21.65 HR22.2 28.91,22.14 28.65,22.39 HR24.1
VIDSCLK: length 37.1
  IN1 w0.127: v1(22.18,10.13) 16.22,10.13 v1(14.6,11.75)
  BOTTOM w0.089: U1.N63 27.59,29.07 27.59,28.03 27.19,27.63 27.19,26.85 27.73,26.3 28.76,26.3 29.69,25.37
  BOTTOM w0.102: 29.69,25.37 29.69,24.91 29.21,24.42 29.21,22.85 30.28,21.79 30.28,21.01 30.58,20.7 30.58,17.51 25.58,12.51 25.58,11.44 24.59,10.46 22.51,10.46 v1(22.18,10.13) ; PR104.2 14.05,12.84 v2(14.56,12.84) 14.56,12.23 14.6,12.19 v1(14.6,11.75)
VIDSOUT: length 38.8
  IN1 w0.127: v1(9.86,12.42) 10.87,13.42 12.43,13.42 12.9,12.95 15.17,12.95 16.44,11.68 v1(24.18,11.68)
  BOTTOM w0.089: U1.L63 26.94,28.66 27.02,28.58 27.02,28.22 26.65,27.85 26.65,26.55 27.84,25.37
  BOTTOM w0.102: v1(9.86,12.42) 8.99,12.42 8.74,12.68 v2(8.74,12.97) 9.02,13.25 PR101.2 ; v1(24.18,11.68) 24.18,12.87 28.27,16.96 28.27,16.97 HR23.2 28.27,18.24 28.27,21.96 28.06,22.17 28.06,25.01 27.95,25.12 27.95,25.25 27.84,25.37
VR_HOT#: length 22.2
  TOP w0.102: v1(13.52,15.25) 13.16,15.25 13,15.41 PC74.1
  BOTTOM w0.102: PU4.30 13.43,15.34 v1(13.52,15.25) 14.68,14.09 14.84,14.09 16.46,12.46 v2(19.92,12.46) 21.97,12.46 26.65,17.14 26.65,19.91 26.52,20.03 HR3.1
VRM_PWRGD: length 275.8
  TOP w0.102: v1(115.92,86.77) 115.92,85.92 115.65,85.65 115.65,83.96 116.45,83.16 116.45,81.18 116.19,80.93 Q13.1 ; v1(140.95,75.23) 140.54,75.63 140.54,78.66 R60466.1 ; SR9206.2 v2(156.4,66.64) 156.4,68.25 155.86,68.8 155.86,72.89 153.14,75.61 v1(153.14,83.08)
  TOP w0.254: PD5.2 8.97,19.18 8.62,19.53 v1(8.08,19.53)
  IN2 w0.102: v1(8.08,19.53) 8.08,25.66 8.29,25.87 10.39,25.87 11.46,26.94 11.46,33.04 10.82,33.67 10.82,45.98 11.41,46.56 11.41,48.61 9.68,50.33 9.15,50.33 7.37,52.12 7.37,62.22 7.12,62.47 7.12,76.35 7.69,76.92 7.69,77.83 9.6,79.75 9.89,79.75 11.79,81.64 11.79,82.69 13.8,84.7 15.45,84.7 16.5,85.75 17.07,85.75 18.52,87.2 21.73,87.2 23.96,89.43 39.65,89.43 40.69,88.4 51.68,88.4 52.45,89.17 54.37,89.17 55.18,88.36 62.36,88.36 63.33,89.32 64.76,89.32 65.18,88.91 67.68,88.91 68.82,90.04 115.48,90.04 116.82,88.71 116.82,87.9 115.92,87 v1(115.92,86.77) 117.16,86.77 118.24,85.69 129.57,85.69 130.52,86.64 132.96,86.64 133.24,86.92 133.24,86.94 133.39,87.1 141.99,87.1 142.44,86.64 146.47,86.64 149.46,83.66 152.55,83.66 v1(153.14,83.08)
  BOTTOM w0.102: v1(115.92,86.77) 115.92,86.74 115.72,86.53 U10.69 ; v1(153.14,83.08) 152.83,83.08 149.28,79.53 149.28,78.43 149,78.15 146.64,78.15 143.97,75.48 141.2,75.48 v1(140.95,75.23)
  BOTTOM w0.254: PR109.1 6.42,20.05 6.55,20.18 7.93,20.18 8.08,20.03 v1(8.08,19.53)
VRM_PWRGD1_A: length 11
  TOP w0.254: v2(8.38,14.8) 8.97,15.39 PD5.1 8.97,17.24 8.84,17.37 v1(8.15,17.37)
  BOTTOM w0.203: 11.47,17.86 11.5,17.89 PU4.3
  BOTTOM w0.254: 11.47,17.86 10.41,17.86 10.19,18.08 PC77.1 9.69,17.82 9.23,17.37 v1(8.15,17.37) 7.64,17.37 7.31,17.7 PR110.2 PR109.2
VSUS_ON: length 100.3
  IN1 w0.102: v1(112.47,69.6) 112.47,63.46 114.14,61.79 115.98,61.79 116.55,62.36 117.62,62.36 117.88,62.1 117.88,61.79 120.14,59.53 120.14,58.51 120.6,58.06 v1(121.59,58.06) ; v1(100.84,82.34) 101.44,81.73 106.18,81.73 107.06,80.85 107.06,79.82 105.86,78.62 103.48,78.62 102.17,77.31 102.17,76.13 101.5,75.45 101.5,75.04 102.1,74.43 102.42,74.43 103.94,72.92 103.94,72.63 105.66,70.91 106.05,70.91 v1(107.06,69.89) 107.9,69.05 108.25,69.05 108.61,68.69 108.61,67.98 108.24,67.61 108.24,66.73 107.75,66.23 107.75,65.27 108.29,64.73 108.29,60.59 108.87,60.01 108.87,58.64 108.67,58.44 108.67,38.72 v1(107.85,37.9)
  IN3 w0.102: v1(107.06,69.89) 107.48,70.31 110,70.31 110.1,70.41 112.14,70.41 112.45,70.1 112.45,69.63 v1(112.47,69.6)
  BOTTOM w0.102: v1(121.59,58.06) 125.03,58.06 PR154.1 ; v1(100.84,82.34) 100.24,82.93 U10.19 97.98,82.93 97.79,83.13 97.79,83.46 97.36,83.89 96.76,83.89 96.6,84.05 v1(95.4,84.05) 94.98,83.63 94.45,83.63 R189.1 ; v1(107.85,37.9) 106.58,39.16 v2(106.5,39.16) 104.9,39.16 104.5,38.75 PQ35.2
WIGIG_DISABLE#_EC: length 97.1
  TOP w0.102: v1(170.08,64.18) 169.57,63.67 169.57,62.27 170.44,61.41 v2(171.98,61.41) 172.37,61.41 174.47,63.52 175.57,63.52 176.43,64.39 D14.2
  IN1 w0.102: v1(165.43,63.52) 166.52,63.52 167.62,64.61 169.65,64.61 v1(170.08,64.18)
  IN3 w0.102: v1(165.43,63.52) 165.43,64.61 165.8,64.98 165.8,68.9 165.42,69.28 165.42,73.2 165.8,73.58 165.8,74.64 166.16,75 166.16,79.51 163.8,81.87 147.07,81.87 146.32,82.62 143.17,82.62 139.71,86.07 133.41,86.07 131.7,84.36 129.59,84.36 128.82,83.6 114.19,83.6 113.51,84.27 112.42,84.27 v1(111.96,83.81)
  BOTTOM w0.102: v1(111.96,83.81) 111.23,83.08 111.23,82.48 111.58,82.13 U10.80
WLAN_DISABLE: length 198.4
  TOP w0.102: v1(122.53,72.07) 122.53,72.66 v2(123.24,73.37) 123.24,74.24 124.23,75.23 124.23,80.92 v1(122.96,82.19) ; R306.2 176.39,57.61 v1(176.8,57.21)
  IN1 w0.102: v1(122.96,82.19) 130.25,82.19 132.31,80.13 132.31,76.73 133.19,75.85 146.26,75.85 146.86,75.25 150.22,75.25 153.91,71.56 155.92,71.56 156.57,70.91 159.81,70.91 161.33,72.42 163.85,72.42 164.31,72.88 167.17,72.88 168.37,71.68 168.88,71.68 168.95,71.76 175.13,71.76 180.32,66.58 180.32,62.7 177.8,60.19 177.8,57.37 177.64,57.21 v1(176.8,57.21)
  IN2 w0.089: v1(37.62,64.5) 38.04,64.09 40.78,64.09 41.44,64.74 42.6,64.74 42.8,64.95 44.49,64.95 44.72,64.71 49.51,64.71
  IN2 w0.102: v1(122.53,72.07) 122.08,72.52 117.95,72.52 117.14,71.71 110.21,71.71 109.67,72.25 108.89,72.25 107.46,73.69 100.29,73.69 99.11,72.51 95.45,72.51 94.74,71.8 92.97,71.8 92.57,72.2 90.07,72.2 88.77,73.5 76.38,73.5 75.59,74.29 68.77,74.29 67.58,73.1 64.74,73.1 64.24,72.6 64.24,72.54 63.7,71.99 57.6,71.99 56.51,73.08 55.58,73.08 54.6,72.1 54.6,69.83 57.79,66.64 57.79,65.11 57.42,64.75 56.2,64.75 56.11,64.84 55.42,64.84 54.9,64.32 49.9,64.32 49.51,64.71
  BOTTOM w0.102: U1.AM7 37.62,64.38 v1(37.62,64.5) ; v1(176.8,57.21) 175.91,57.21 174.91,56.2 174.6,56.2 174,55.6 CONWIFI.56
WLAN_DISABLE2: length 186.3
  TOP w0.089: v1(38.23,65.34) 37.84,64.94 37.36,64.94 37.19,65.12 37.19,65.55 37.57,65.93 37.57,66.36 39.96,68.75 39.96,69.44 40.49,69.97 ; 40.65,70.14 40.65,71.57
  TOP w0.102: 40.65,71.57 40.65,73.74 41.2,74.29 41.51,74.29 42.67,75.45 42.67,76.09 42.85,76.27 42.85,76.85 43.16,77.16 43.93,77.16 44.23,77.46 44.48,77.46 44.86,77.84 45.63,77.84 46.08,78.29 46.08,79.59 46.64,80.15 47.37,80.15 47.75,80.54 47.75,81.9 49.34,83.49 51.66,83.49 52.37,84.19 55.5,84.19 58.51,87.2 64.67,87.2 64.97,86.91 65.95,86.91 66.71,87.67 71.31,87.67 71.75,88.11 82.82,88.11 83.44,87.49 v1(83.44,86.94) ; 40.49,69.97 40.65,70.14 ; v1(176.71,55.39) 176.3,55.8 176.07,55.8 R450.2 175.36,56.96 174.98,57.35 174.73,57.35 174.25,57.83 172.76,57.83 172.22,58.37 168.72,58.37 167.03,60.07 167.03,65.71 166.68,66.06 166.68,69.99 167.39,70.71 167.39,75.79 v2(165.69,77.49) 165.18,78 v1(165.18,78.96)
  IN2 w0.102: v1(165.18,78.96) 164.85,79.29 157.46,79.29 155.59,81.16 145.71,81.16 142.68,84.18 141.46,84.18 140.95,84.69 130.98,84.69 130.23,83.94 120.63,83.94 120.13,83.43 114.83,83.43 112.74,85.51 98.4,85.51 98.22,85.69 93.98,85.69 93.47,86.2 89.76,86.2 89.02,86.94 v1(83.44,86.94)
  BOTTOM w0.089: U1.AN5 38.43,65.07 38.43,65.14 38.35,65.22 v1(38.23,65.34)
  BOTTOM w0.102: CONWIFI.54 173.93,55.1 174.65,55.82 176.28,55.82 v1(176.71,55.39)
WRST#: length 13.7
  BOTTOM w0.102: U20.11 151.8,74.81 151.59,75.02 151.59,76.06 151.39,76.27 C195.1 150.65,76.66 150.79,76.8 R369.2 151.61,78.11 151.61,79.01 151.06,79.57 150.32,79.57 150.22,79.47 D24.1 150.22,78.3 149.66,77.74 147.19,77.74 146.76,77.31 v2(146.76,76.85)
X2402_IN: length 2.1
  BOTTOM w0.102: R216.2 94.73,74.65 X2.1
X2402_OUT: length 5.7
  BOTTOM w0.102: v2(98.63,73.5) 98.41,73.28 96.88,73.28 96.47,72.86 R211.2 96.46,73.22 96.35,73.33 C81.1 95.63,74.53 X2.4
XDP_BPM0: length 69.3
  TOP w0.089: v1(25.07,31.45) 25.07,31.46 24.31,30.7 v2(24.31,30.5)
  TOP w0.102: XDP1.21 72.28,5.24 v1(71.71,5.81)
  IN2 w0.089: v1(25.07,31.45) 25.07,31.46 25.65,30.88 25.65,29.65 25.02,29.03 25.02,26.45 27.11,24.36 27.11,22.83
  IN2 w0.102: v1(71.71,5.81) 71.08,5.19 67.07,5.19 64.72,7.54 53.36,7.54 52.62,8.27 48.57,8.27 41.26,15.58 30.01,15.58 28.53,17.06 28.53,17.54 27.11,18.96 27.11,22.83
  BOTTOM w0.089: v1(25.07,31.45) 25.16,31.45 U1.J60
XDP_BPM1: length 69.4
  TOP w0.102: v1(72.34,5.81) 72.78,5.37 XDP1.23 ; v2(52.35,7.84) v1(51.84,7.33)
  IN2 w0.089: 26.82,22.83 26.82,24.4 24.85,26.38 24.85,29.15 25.47,29.78 25.47,30.4 v1(25.07,30.81)
  IN2 w0.102: v1(72.34,5.81) 71.52,4.98 66.99,4.98 64.64,7.33 v1(51.84,7.33) 51.56,7.33 50.83,8.07 48.49,8.07 41.18,15.38 29.11,15.38 26.82,17.66 26.82,22.83
  BOTTOM w0.089: U1.H60 24.98,30.81 v1(25.07,30.81)
XDP_DBRESET#_R: length 10.2
  TOP w0.102: v2(79.5,16.1) 80.03,15.57 GR6.2 81.72,15.57 GR15.2 80.72,14.51 80.72,13.1 81.2,12.62 GC2.1 80.74,12.13 79.86,12.13 79.63,11.9 78.97,11.9 78.78,11.71 XDP1.48
XDP_PRDY#: length 66.2
  TOP w0.089: v2(23.39,26.97) 23.86,27.43 23.86,28.43 24.09,28.66 24.42,28.66 25.18,27.91 v1(25.45,27.91)
  TOP w0.102: v1(68.78,5.81) 68.28,5.3 XDP1.5
  IN2 w0.089: v1(25.45,27.91) 26.19,27.91 27.32,26.78 27.32,22.83
  IN2 w0.102: v1(68.78,5.81) 68.37,5.39 67.16,5.39 64.81,7.74 53.44,7.74 52.71,8.48 48.66,8.48 41.35,15.78 30.1,15.78 28.81,17.07 28.81,17.69 28.06,18.44 28.06,20.77 27.32,21.51 27.32,22.83
  BOTTOM w0.089: v1(25.45,27.91) 25.83,28.29 25.83,28.73 25.73,28.83 25.73,29.35 25.45,29.64 U1.J62
XDP_PREQ#: length 62.6
  TOP w0.089: v1(26.62,28.41) 26.62,26.66 v2(26.82,26.46)
  TOP w0.102: v1(68.15,5.81) 67.78,5.43 XDP1.3
  IN2 w0.089: v1(26.62,28.41) 26.98,28.41 27.6,27.79 27.6,22.83
  IN2 w0.102: 27.6,22.83 27.6,21.52 28.28,20.83 28.28,18.6 29.07,17.81 29.07,17.1 30.18,15.99 41.43,15.99 48.74,8.68 52.81,8.68 53.54,7.94 64.89,7.94 66.61,6.23 67.73,6.23 v1(68.15,5.81)
  BOTTOM w0.089: U1.K62 26.57,29.45 26.57,28.47 v1(26.62,28.41)
XDP_RST#_R: length 62
  TOP w0.102: GR14.2 121.62,24.86 v2(121.46,24.71) 117.48,20.72 111.97,20.72 110.03,18.79 110.03,17.19 106.93,14.09 104.77,14.09 102.97,12.29 102.97,11.63 100.81,9.46 95.32,9.46 92.98,11.8 87.72,11.8 87.29,12.24 87.29,13.14 87.78,13.63 v1(87.78,14.93) ; v1(79.83,14.32) 79.83,12.58 79.36,12.11 78.82,12.11 78.28,11.57 XDP1.46
  BOTTOM w0.102: v1(87.78,14.93) 87.78,14.44 86.83,13.48 80.67,13.48 v1(79.83,14.32)
XDP_TCK: length 269.1
  TOP w0.089: v1(23.58,30.82) 23.58,30.75 22.76,29.93 22.76,25.86 GR2.1
  TOP w0.102: GR19.1 60.28,7.39 60.5,7.39 61.22,6.67 62.02,6.67 GR18.1 63.27,7.15 64.09,6.34 v1(64.09,5.94) ; v1(164.68,71.98) v2(162.59,71.98) 161.22,71.98 160.11,73.08 158.79,73.08 157.93,73.94 R430.2 ; v1(112.68,17.82) 112.68,17.29 107.65,12.26 105.53,12.26 104.83,11.56 104.83,8.6 103.69,7.46 103.69,6.21 101.91,4.44 97.41,4.44 96.67,3.7 88.11,3.7 85.26,6.56 83.76,6.56 83.52,6.32 v1(82.96,6.32) 82.5,5.86 81.66,5.86 81.28,5.48 XDP1.57
  IN1 w0.102: v1(64.09,5.94) 64.84,5.19 76.1,5.19 76.75,5.83 82.48,5.83 v1(82.96,6.32)
  IN2 w0.089: v1(23.58,30.82) 23.97,30.43 23.97,29.12 23.86,29 23.86,26.55 24.17,26.23 24.48,26.23 26.39,24.32 26.39,22.83
  IN2 w0.102: v1(82.96,6.32) 82.51,6.76 78.69,6.76 75.89,3.97 64.89,3.97 63.23,5.62 55.51,5.62 54.7,4.81 50.75,4.81 47.04,8.51 47.04,8.94 41.01,14.97 28.94,14.97 26.39,17.52 26.39,22.83
  IN3 w0.102: v1(164.68,71.98) 164.68,69.65 165.6,68.74 165.6,66.25 164.76,65.41 164.76,61.24 162.24,58.73 162.24,44.34 165.91,40.67 v1(165.91,39.08)
  BOTTOM w0.089: U1.E60 23.27,31.13 v1(23.58,30.82)
  BOTTOM w0.102: v1(112.68,17.82) 112.68,21.57 113.85,22.74 126.39,22.74 127.07,22.05 135.61,22.05 138.48,19.18 144.74,19.18 148.13,22.57 148.13,26.1 158.13,36.1 163.55,36.1 165.91,38.46 v1(165.91,39.08)
XDP_TCK1: length 28.2
  TOP w0.102: v1(64.85,5.94) 64.34,6.44 64.34,6.75 62.9,8.18 GR17.1 ; v1(82.28,6.34) 82.08,6.14 81.26,6.14 80.78,5.66 XDP1.55
  IN1 w0.102: v1(64.85,5.94) 65.39,5.39 76.02,5.39 76.77,6.14 82.08,6.14 v1(82.28,6.34)
  BOTTOM w0.102: v2(64.52,3.55) 64.85,3.88 v1(64.85,5.94)
XDP_TDI: length 81.5
  IN2 w0.089: 26.62,22.83 26.62,24.35 24.67,26.31 24.67,26.61 v1(24.26,27.02)
  IN2 w0.102: 26.62,22.83 26.62,17.58 29.02,15.18 41.09,15.18 47.25,9.02 47.25,8.59 50.83,5.01 54.55,5.01 55.36,5.82 63.32,5.82 64.97,4.17 75.81,4.17 78.6,6.96 83.63,6.96 v1(84.46,6.14)
  BOTTOM w0.089: v1(24.26,27.02) 24.18,27.02 23.86,27.34 23.86,28.71 23.95,28.8 U1.F63
  BOTTOM w0.102: GU1.3 84.6,5.23 84.46,5.38 v1(84.46,6.14) 84.28,6.32 v2(83.75,6.32)
XDP_TDI_BUF: length 20.3
  TOP w0.102: v1(87.63,5.96) 88.12,6.44 89.54,6.44 90.67,7.57 90.67,8.07 88.86,9.87 88.79,9.87 86.68,11.99 86.68,15.07 v2(85.98,15.77) 85.9,15.84 85.14,15.84 GR21.2 84.84,14.9 84.53,14.59 84.53,14.11 GR20.1
  BOTTOM w0.102: v1(87.63,5.96) 87.63,5.56 86.66,4.58 GU1.2
XDP_TDO: length 93.8
  TOP w0.089: v2(24.26,23.72) 24.59,24.05 v1(24.59,25.14)
  IN2 w0.089: 25.15,22.75 24.28,23.61 24.28,24.27 24.59,24.58 v1(24.59,25.14)
  IN2 w0.102: v1(89.1,7) 88.76,6.66 88.76,5.78 88.23,5.25 88.06,5.25 86.36,3.55 64.73,3.55 63.07,5.21 59.12,5.21 58.05,4.14 50.79,4.14 49.64,5.29 48.34,5.29 45.32,8.31 45.32,10.08 40.84,14.57 28.17,14.57 25.15,17.58 25.15,22.75
  BOTTOM w0.089: 24.43,25.37 24.43,26.26 23.66,27.03 23.66,29.54 U1.F62
  BOTTOM w0.102: GR1.2 25.82,23.91 v1(24.59,25.14) 24.43,25.29 24.43,25.37 ; GU1.11 90.68,5.88 89.56,7 v1(89.1,7)
XDP_TDO_BUF: length 29.2
  TOP w0.102: v1(89.51,5.96) 89.8,5.96 90.87,7.03 90.87,8.82 v2(89.92,9.77) 89.49,10.2 88.75,10.2 86.88,12.07 86.88,13.3 87.29,13.71 v1(87.29,14.53) ; XDP1.52 79.78,11.67 80.04,11.93 80.93,11.93 81.08,12.08 81.66,12.08 82.19,12.61 GR5.2 81.99,13.31 v1(81.99,14.32) 81.99,14.76 GR23.1 82.79,15.54 GR16.2
  BOTTOM w0.102: v1(81.99,14.32) 82.42,13.89 85.88,13.89 86.52,14.53 v1(87.29,14.53) ; GU1.12 90.24,5.23 v1(89.51,5.96)
XDP_TMS: length 243.1
  TOP w0.102: v1(111.91,17.82) 111.91,16.88 107.49,12.46 105.44,12.46 104.62,11.64 104.62,8.8 100.47,4.64 97.33,4.64 96.59,3.9 88.46,3.9 87.22,5.15 87.22,6.13 87.9,6.81 88.27,6.81 88.87,7.42 89.78,7.42 v1(90.25,7.89) ; v1(165.03,73.92) 164.97,73.92 164.92,73.87 164.92,73.3 164.49,72.87 v2(164.29,72.87) R428.2
  IN2 w0.089: 24.59,22.83 23.22,24.2 23.22,26.59 v1(22.3,27.5)
  IN2 w0.102: 24.59,22.83 24.94,22.47 24.94,17.5 28.08,14.36 40.76,14.36 45.04,10.08 45.04,8.2 48.15,5.08 49.56,5.08 50.7,3.94 58.41,3.94 59.48,5.01 62.96,5.01 64.63,3.34 87.49,3.34 90.25,6.1 v1(90.25,7.89)
  IN3 w0.102: v1(165.28,39.08) 165.28,40.62 161.97,43.92 161.97,58.74 164.54,61.32 164.54,65.48 165.39,66.33 165.39,68.64 163.98,70.05 163.98,72.87 v1(165.03,73.92)
  BOTTOM w0.089: v1(22.3,27.5) 21.9,27.9 21.9,28.55 22.17,28.81 22.17,29.52 22.25,29.6 22.25,29.95 22.62,30.32 22.84,30.32 22.99,30.48 U1.E61
  BOTTOM w0.102: v1(111.91,17.82) 111.91,21.09 113.76,22.94 126.47,22.94 127.16,22.25 135.69,22.25 138.56,19.38 144.66,19.38 147.8,22.53 147.8,26.06 158.04,36.3 162.5,36.3 v1(165.28,39.08) ; v1(90.25,7.89) 90.31,7.83 GU1.8
XDP_TRST#: length 120.1
  TOP w0.089: GR3.1 43.21,25.52 v2(43.51,25.82) 43.66,25.96 43.66,26.8 v1(43.2,27.25) 42.65,27.25 40.64,29.26
  TOP w0.102: v1(22.76,31.45) 22.74,31.45 23.97,32.67 27.41,32.67 27.54,32.54 33.78,32.54 35.21,31.11 38.36,31.11 40.21,29.26 40.64,29.26
  IN2 w0.089: v1(22.76,31.45) 22.74,31.45 23.16,31.03 23.16,26.99 24.13,26.03 24.44,26.03 25.52,24.95 25.52,22.63
  IN2 w0.102: 25.52,22.63 25.52,17.5 28.25,14.77 40.93,14.77 45.56,10.14 45.56,8.36 48.43,5.49 49.73,5.49 50.87,4.35 57.49,4.35 58.56,5.41 63.15,5.41 64.81,3.75 84.29,3.75 87.71,7.17 v1(87.71,7.89)
  BOTTOM w0.089: U1.AU62 41.51,29.49 41.51,28.96 42.01,28.46 42.01,28.3 42.5,27.8 42.5,27.8 43.05,27.25 v1(43.2,27.25) ; v1(22.76,31.45) 23.09,31.78 U1.E59
  BOTTOM w0.102: v1(87.71,7.89) 87.71,7.61 87.28,7.18 GU1.6
XDP_TRST#_BUF: length 8.9
  TOP w0.102: XDP1.54 80.28,8.57 80.91,7.93 82.92,7.93 v1(83.34,8.35)
  BOTTOM w0.102: GU1.5 85.75,6.52 84.81,6.52 84.02,7.31 v2(84.02,8.04) 83.72,8.35 v1(83.34,8.35)
XTAL_24M_IN: length 16.6
  BOTTOM w0.089: 18.7,53.31 19.93,53.31 20.14,53.09 U1.A25
  BOTTOM w0.102: v2(12.14,44.04) 12.45,44.35 CKX1.1 13.73,46.96 14.73,46.96 15.15,46.54 CKC2.1 16.17,46.54 16.2,46.5 CKR1.1 17.3,47.08 17.3,47.26 18.62,48.58 18.62,51.11 18.19,51.54 18.19,52.8 18.7,53.31
XTAL_24M_OUT: length 12.9
  BOTTOM w0.089: 18.51,53.6 20.14,53.6 20.31,53.43 20.82,53.43 U1.B25
  BOTTOM w0.102: 18.51,53.6 17.88,52.97 17.88,51.4 18.3,50.98 18.3,49.16 v2(17.5,48.35) 17.17,48.03 17.17,47.84 CKR1.2 15.78,47.39 CKC1.1 15.29,47.88 CKX1.3
N190577: length 2
  TOP w0.102: PC47.1 11.51,48.55 11.71,48.35 12.09,48.35 v2(12.7,47.74)
N190717:
  vias: v2(15.65,47.72)
N336868: length 2.1
  TOP w0.254: PR116.1 17.76,11.14 PC82.2 v2(16.7,10.06)
N415135: length 9.4
  TOP w0.102: v2(145.21,40.84) 145.21,39.9 v1(145.24,39.87)
  TOP w0.254: PR73.2 146.37,40.72 146,40.35 145.72,40.35 v1(145.24,39.87)
  BOTTOM w0.254: PQ13.6 141.68,42.11 141.68,40.32 142.54,39.46 144.83,39.46 v1(145.24,39.87)
N416456: length 24.3
  TOP w0.254: PR79.2 146.18,39.59 v1(145.92,39.84)
  BOTTOM w0.254: v1(145.92,39.84) 145.18,39.1 142.41,39.1 141.2,40.3 138.18,40.3 v2(136.86,41.62) 136.22,42.26 136.22,42.64 136.78,43.2 136.78,44.36 ; PQ13.3 138.53,44.01 138.18,44.36 136.78,44.36 ; 136.78,44.36 136.48,44.67 136.48,47.13 136.79,47.44 PR85.2 PC65.1 137.44,49.08 138.25,49.89 PU3.6
N438555: length 1.6
  BOTTOM w0.356: PQ25.4 50.42,86.09 PR197.1
N443953: length 3
  TOP w0.102: v2(134.14,20.08) 133.82,19.77 PQ31.3 132.71,20.35 132.68,20.39 PR203.2
N456425: length 7.8
  TOP w0.203: PU7.10 110.02,63.47 109.84,63.64 108.46,63.64 108,64.1 108,64.86 107.43,65.43 PR172.2 106.89,65.72 106.83,65.77 v2(106.18,65.77) 106.18,65.49 106.66,65.01 107.18,65.01 107.38,64.81 PR171.1
N456604: length 2.6
  TOP w0.203: v2(105.08,63.01) 105.62,63.01 105.98,62.65 107.57,62.65
N479647: length 8.7
  TOP w0.254: 128.58,63.48 129.69,63.48 v2(130.02,63.81)
  TOP w0.356: PQ32.3 127.91,59.02 128.42,59.53 128.42,62.34 PR209.2 128.58,63.48
N19364135: length 4.6
  BOTTOM w0.457: CON6.4 159.44,87.59 L4.2 159.99,87.82 v2(159.99,86.97) 159.81,86.79 CON6.5
N19719213: length 14.3
  TOP w0.102: Q3.4 108.78,73.86 108.95,74.03 v1(108.95,75.22) ; v2(117.3,69.28) 116.43,69.28 v1(115.76,69.96)
  IN1 w0.102: v1(108.95,75.22) 109.45,75.22 114.71,69.96 v1(115.76,69.96)
  BOTTOM w0.102: Q4.3 116.1,69.61 v1(115.76,69.96)
N19719354: length 4.4
  BOTTOM w0.254: R230.2 117.3,63.89 117.3,63.31 v2(116.84,62.86)
  BOTTOM w0.457: R230.2 117.05,65.06 Q4.1
N19719387: length 5.4
  TOP w0.102: v2(104.32,70.86) 104.32,71.04 104.85,71.57 104.85,72.33 105.12,72.6 105.12,73.13 104.98,73.27 R228.2 105.61,74.45 105.61,74.9 105.88,75.16 Q3.1
N19750284: length 4.5
  TOP w0.102: v2(171.78,63.8) 171.78,65.91 R316.2 171.67,66.53 172.12,66.98 Q29.6
N19750307: length 10.1
  TOP w0.102: v2(180.16,67.3) 179.63,67.84 178.03,67.84 177.67,67.48 177.67,65.96 177.5,65.78 176.35,65.78 175.79,66.34 175.79,67.31 R315.2 174.51,68.05 174.13,68.43 Q27.3
N19750343: length 3.7
  TOP w0.102: Q33.3 178.6,69.01 179.16,69.57 R322.2 180.5,70.02 v2(181.21,70.02)
N19750351: length 14.1
  TOP w0.102: v2(182.58,68.57) 181.18,68.57 180.65,68.04 177.9,68.04 177.47,67.61 177.47,66.18 177.34,66.06 176.48,66.06 176.35,66.18 176.35,69.62 R321.2 175.77,70.83 175.59,71.01 Q31.3
N19750353: length 3
  TOP w0.102: Q31.6 174.29,74.28 174.18,74.39 173.92,74.39 173.75,74.55 R319.2 173.75,75.62 v2(174.3,76.17)
N19785814:
  vias: v2(15.8,68.62)
N19785881: length 0.9
  TOP w0.254: v1(131.57,68.24) 131.4,68.06 v2(131.4,67.45)
