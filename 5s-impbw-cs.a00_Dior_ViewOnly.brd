# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ21: length 55.8
  TOP w0.089: v1(38.73,49.94) 38.18,49.38 v2(38.18,49.23)
  IN1 w0.089: 40.84,39.13 39.51,40.47 39.51,40.85 38.91,41.44 38.91,41.58 38.6,41.9 36.47,41.9 35.97,42.39 35.97,45.33 36.08,45.43 36.08,48.69 36.56,49.18 37.97,49.18 v1(38.73,49.94)
  IN1 w0.127: v1(61.67,35.74) 61.24,36.17 60.74,36.17 58.76,38.15 55.95,38.15 55.83,38.27 55.83,38.93 55.7,39.06 55.45,39.06 55.32,38.93 55.32,38.27 55.19,38.15 54.94,38.15 54.81,38.27 54.81,38.93 54.68,39.06 54.43,39.06 54.3,38.93 54.3,38.27 54.18,38.15 53.92,38.15 53.8,38.27 53.8,38.93 53.67,39.06 53.41,39.06 53.29,38.93 53.29,38.27 53.16,38.15 52.91,38.15 52.78,38.27 52.78,38.93 52.65,39.06 52.4,39.06 52.27,38.93 52.27,38.27 52.14,38.15 51.89,38.15 51.76,38.27 51.76,38.93 51.64,39.06 51.38,39.06 51.26,38.93 51.26,38.27 51.13,38.15 50.87,38.15 50.75,38.27 50.75,38.93 50.62,39.06 50.37,39.06 50.24,38.93 50.24,38.27 50.11,38.15 49.86,38.15 49.73,38.27 49.73,38.93 49.6,39.06 49.35,39.06 49.22,38.93 49.22,38.27 49.1,38.15 48.67,38.15 48.34,38.48 41.5,38.48 40.84,39.13
  BOTTOM w0.089: U1.AN29 38.73,49.94 v1(38.73,49.94)
  BOTTOM w0.102: v1(61.67,35.74) 61.67,35.5 62.16,35.02 62.16,33.69 61.5,33.04 61.27,33.04 60.68,32.45 DIMM1.53
M_CHB_DQ22: length 54.4
  TOP w0.089: v2(41.2,52.11) 40.51,52.11 v1(40.38,51.98)
  IN1 w0.089: v1(40.38,51.98) 39.88,51.48 39.88,50.41 39.96,50.33 39.96,49.68 39.01,48.73 39.01,45.42 39.35,45.08 40.31,45.08 40.32,45.1 40.65,45.1 40.89,44.86 40.89,43.98 41.02,43.86 41.12,43.75 41.12,43.66
  IN1 w0.127: 41.12,43.66 41.12,43.22 40.85,42.95 40.85,40.79 41.64,40 42.92,40 43.26,39.67 43.26,39.28 43.63,38.91 45.06,38.91 45.94,39.78 46.18,39.78 46.31,39.91 46.31,40.28 46.43,40.4 46.69,40.4 46.82,40.28 46.82,39.91 46.94,39.78 47.2,39.78 47.32,39.91 47.32,40.28 47.45,40.4 47.7,40.4 47.83,40.28 47.83,39.91 47.96,39.78 48.21,39.78 48.34,39.91 48.34,40.28 48.47,40.4 48.72,40.4 48.85,40.28 48.85,39.91 48.97,39.78 49.23,39.78 49.36,39.91 49.36,40.28 49.48,40.4 49.74,40.4 49.86,40.28 49.86,39.91 49.99,39.78 50.24,39.78 50.37,39.91 50.37,40.28 50.5,40.4 50.75,40.4 50.88,40.28 50.88,39.91 51.01,39.78 51.26,39.78 51.39,39.91 51.39,40.28 51.51,40.4 51.77,40.4 51.9,40.28 51.9,39.91 52.02,39.78 58.48,39.78 58.93,39.34 59.42,39.34 59.86,39.78 60.62,39.78 62.64,37.76 62.64,36.58 62.99,36.22 v1(62.99,35.73)
  BOTTOM w0.089: v1(40.38,51.98) 40.03,51.63 U1.AR28
  BOTTOM w0.102: DIMM1.50 66.31,31.55 64.28,33.58 64.28,34.53 63.08,35.73 v1(62.99,35.73)
M_CHB_DQ23: length 54.4
  IN1 w0.089: 41.04,39.4 41.04,40.19 39.94,41.29 39.94,41.59 39.83,41.71 39.83,42.78 40.11,43.06 40.11,43.45 39.69,43.87 38.93,43.87 38.33,44.47 38.33,45.03 38.84,45.53 38.84,48.81 39.78,49.75 39.78,50.23 39.5,50.51 39.5,51.46 v1(39.04,51.91)
  IN1 w0.127: 41.04,39.4 41.74,38.69 45.2,38.69 45.94,39.43 56.3,39.43 56.43,39.3 56.43,38.63 56.56,38.5 56.81,38.5 56.94,38.63 56.94,39.3 57.07,39.43 57.32,39.43 57.45,39.3 57.45,38.63 57.57,38.5 57.83,38.5 57.96,38.63 57.96,39.3 58.08,39.43 58.34,39.43 58.46,39.3 58.46,38.63 58.59,38.5 58.99,38.5 59.09,38.5 60.01,39.42 60.19,39.42 60.37,39.24 60.37,39.06 59.51,38.21 59.51,37.9 59.91,37.51 60.09,37.51 60.42,37.84 60.6,37.84 60.78,37.66 60.78,37.48 60.45,37.15 60.45,36.97 60.75,36.66 60.93,36.66 61.72,37.46 61.95,37.46 62.21,37.2 62.21,37.03 61.8,36.62 61.8,36.29 v1(62.36,35.73)
  BOTTOM w0.089: v1(39.04,51.91) 39.38,51.57 U1.AP28
  BOTTOM w0.102: v1(62.36,35.73) 62.36,35.37 62.49,35.25 62.49,33.55 61.52,32.58 61.32,32.58 60.59,31.85 DIMM1.51
M_CHB_DQ24: length 59.4
  TOP w0.102: v1(63.07,36.76) 62.47,36.16 60.12,36.16 58.17,34.2 58.17,33.72 58.07,33.62 57.81,33.62 57.71,33.72 57.71,34.18 57.51,34.38 56.67,34.38 56.47,34.18 v2(56.47,33.81) 56.28,33.62 54.55,33.62 54.44,33.72 54.44,33.94 54.34,34.04 54.14,34.04 54.04,33.94 54.04,33.72 53.94,33.62 53.73,33.62 53.63,33.72 53.63,33.94 53.53,34.04 53.33,34.04 53.22,33.94 53.22,33.72 53.12,33.62 52.92,33.62 52.82,33.72 52.82,33.94 52.72,34.04 52.51,34.04 52.41,33.94 52.41,33.72 52.31,33.62 52.11,33.62 52.01,33.72 52.01,33.94 51.9,34.04 51.7,34.04 51.6,33.94 51.6,33.72 51.5,33.62 51.29,33.62 51.19,33.72 51.19,33.94 51.09,34.04 50.89,34.04 50.79,33.94 50.79,33.72 50.68,33.62 50.48,33.62 50.38,33.72 50.38,33.94 50.28,34.04 50.08,34.04 49.97,33.94 49.97,33.72 49.87,33.62 49.67,33.62 49.57,33.72 49.57,33.94 49.47,34.04 49.26,34.04 49.16,33.94 49.16,33.72 49.06,33.62 48.49,33.62 47.47,34.64 47.09,34.64 46.05,35.68 46.05,35.68 45.81,35.92 45.8,35.92 45.77,35.95 39.78,35.95 38.67,37.05 38.01,37.05 37.97,37.02 37.42,37.02 37.39,37.05 36.65,37.05 34.62,39.08 34.62,49.54 35.01,49.93 35.57,49.93 36.1,50.47 36.1,51.92 36.78,52.6 38.14,52.6 38.24,52.49 38.64,52.49 v1(39.04,52.9)
  BOTTOM w0.089: v1(39.04,52.9) 38.73,52.59 U1.AN26
  BOTTOM w0.102: DIMM1.69 61.22,37.25 61.71,36.76 v1(63.07,36.76)
M_CHB_DQ25: length 58.1
  TOP w0.102: v1(39.72,51.93) 39.64,51.93 39.11,51.4 36.94,51.4 36.68,51.14 36.68,49.3 35.97,48.59 35.97,39.5 36.49,38.98 40.27,38.98 40.3,39.01 40.63,39.01 41.76,37.88 41.76,37.75 41.99,37.51 42.9,37.51 43.9,36.52 46.3,36.52 47.36,35.45 48.34,35.45 48.46,35.32 48.46,35.12 48.55,35.04 49.02,35.04 49.12,35.14 49.12,35.57 49.22,35.67 49.42,35.67 49.53,35.57 49.53,35.14 49.63,35.04 49.83,35.04 49.93,35.14 49.93,35.57 50.03,35.67 50.24,35.67 50.34,35.57 50.34,35.14 50.44,35.04 50.64,35.04 50.74,35.14 50.74,35.57 50.85,35.67 51.05,35.67 51.15,35.57 51.15,35.14 51.25,35.04 51.46,35.04 51.56,35.14 51.56,35.57 51.66,35.67 51.86,35.67 51.96,35.57 51.96,35.14 52.07,35.04 52.27,35.04 52.37,35.14 52.37,35.57 52.47,35.67 52.68,35.67 52.78,35.57 52.78,35.14 52.88,35.04 53.08,35.04 53.18,35.14 53.18,35.57 53.28,35.67 53.49,35.67 53.59,35.57 53.59,35.14 53.69,35.04 53.89,35.04 54,35.14 54,35.57 54.1,35.67 58.23,35.67 59.71,37.15 59.99,37.15 61.67,37.15 v2(62.01,37.49) 62.68,38.16 65.46,38.16 65.54,38.08 v1(65.54,37.73)
  BOTTOM w0.089: v1(39.72,51.93) 39.72,52.04 U1.AR26
  BOTTOM w0.102: DIMM1.70 66.64,37.55 66.52,37.43 66.52,37.38 66.42,37.28 66.04,37.28 65.59,37.73 v1(65.54,37.73)
M_CHB_DQ26: length 58.2
  TOP w0.102: v1(40.59,52.94) 40.35,52.94 39.75,52.34 38.76,52.34 38.73,52.3 38.16,52.3 38.06,52.4 36.86,52.4 36.29,51.84 36.29,50.39 35.65,49.74 35.09,49.74 34.81,49.46 34.81,39.16 36.72,37.25 37.57,37.25 37.59,37.24 37.92,37.24 37.93,37.24 38.75,37.24 38.96,37.03 39.88,37.03 39.94,36.97 41.11,36.97 41.16,36.93 41.16,36.45 41.26,36.35 41.47,36.35 41.57,36.45 41.57,36.93 41.67,37.03 41.87,37.03 41.98,36.93 41.98,36.45 42.08,36.35 42.28,36.35 42.38,36.45 42.38,36.93 42.48,37.03 42.85,37.03 43.74,36.14 45.99,36.14 47.3,34.83 47.75,34.83 48.2,34.37 54.48,34.37 v2(54.81,34.71) 55.11,35.01 58.51,35.01 59.99,36.49 62.21,36.49 62.9,37.18 63.25,37.18 63.53,36.9 v1(63.53,36.29)
  BOTTOM w0.089: v1(40.59,52.94) 40.23,53.3 U1.AR25
  BOTTOM w0.102: v1(63.53,36.29) 63.48,36.34 61.63,36.34 61.32,36.65 DIMM1.67
M_CHB_DQ27: length 59
  TOP w0.102: v1(39.72,53.82) 39.31,54.23 35.7,54.23 33.45,51.98 33.45,35.26 36.26,32.45 36.62,32.45 37.53,31.54 38.2,31.54 38.2,31.54 38.54,31.54 38.54,31.54 39.15,31.54 39.4,31.79 39.4,31.99 39.66,32.25 39.99,32.25 40.22,32.47 40.6,32.47 41.64,31.43 v2(43.99,31.43) 46.84,31.43 47.09,31.18 59.45,31.18 61.52,33.25 v1(61.52,33.7)
  BOTTOM w0.089: U1.AP25 39.72,53.64 v1(39.72,53.82)
  BOTTOM w0.102: DIMM1.59 60.97,34.25 v1(61.52,33.7)
M_CHB_DQ28: length 60.8
  TOP w0.102: v1(34.47,51.88) 34.98,51.37 34.98,51.09 34.75,50.86 34.75,50.59 34.02,49.86 34.02,38.87 34.65,38.25 34.65,37.07 34.82,36.9 35.87,36.9 35.99,36.77 35.99,35.72 36.41,35.31 36.9,35.31 37.06,35.15 37.06,34.38 37.21,34.24 40.6,34.24 40.84,33.99 40.84,33.7 40.98,33.56 41.54,33.56 41.61,33.62 41.61,33.93 41.68,34 41.96,34 42.08,33.88 42.08,33.03 42.18,32.93 43.2,32.93 43.3,33.03 43.3,33.49 43.4,33.6 46.74,33.6 46.92,33.42 46.92,33.01 47.09,32.84 47.49,32.84 47.65,32.68 47.65,32.37 47.85,32.17 58.68,32.17 v2(59.01,32.51) 59.41,32.9 59.75,32.9 60,33.14 60,34.02 60.43,34.46 61.9,34.46 62.35,34 62.35,33.76 62.6,33.52 64.1,33.52 64.19,33.61 64.19,33.85 64.29,33.96 64.51,33.96 64.6,33.87 64.6,33.49 64.73,33.37 65.89,33.37 65.99,33.47 65.99,33.61 v1(65.67,33.93)
  BOTTOM w0.089: v1(34.47,51.88) 34.83,52.25 35.94,52.25 36.04,52.35 U1.AK26
  BOTTOM w0.102: DIMM1.56 66.25,33.35 65.68,33.93 65.66,33.93 65.66,33.93 v1(65.67,33.93)
M_CHB_DQ29: length 60.3
  TOP w0.102: v1(38.4,51.82) 38.11,52.11 38.08,52.11 37.98,52.21 36.94,52.21 36.49,51.76 36.49,49.38 35.78,48.67 35.78,39.69 35.41,39.33 35.41,38.83 36.12,38.12 41.12,38.12 41.92,37.32 42.82,37.32 43.82,36.33 46.22,36.33 47.45,35.09 47.95,35.09 48.34,34.71 54.03,34.71 54.67,35.34 58.37,35.34 59.85,36.82 62.07,36.82 63.08,37.83 64.09,37.83 65.18,36.74 67.01,36.74 67.63,37.37 v2(67.63,37.76) 67.63,38.35 67.46,38.52 67.1,38.52 67,38.42 67,37.57 66.73,37.31 65.35,37.31 64.93,37.73 v1(64.9,37.73)
  BOTTOM w0.089: v1(38.4,51.82) 38.08,52.14 U1.AM26
  BOTTOM w0.102: v1(64.9,37.73) 64.93,37.73 65.71,36.95 DIMM1.68
M_CHB_DQ30: length 60.9
  TOP w0.102: v1(37.13,53.82) 36.73,53.42 36.39,53.42 35.49,52.52 34.26,52.52 33.64,51.9 33.64,37.02 v2(33.94,36.72) 34.21,36.45 34.21,36.21 33.64,35.64 33.64,35.46 33.77,35.33 33.89,35.33 34.47,35.92 34.62,35.92 34.76,35.77 34.76,35.63 34.2,35.07 34.2,34.9 34.35,34.75 34.49,34.75 34.84,35.11 34.99,35.11 35.13,34.96 35.13,34.82 34.78,34.47 34.78,34.32 34.99,34.11 35.11,34.11 35.45,34.44 35.78,34.44 36.17,34.06 36.17,33.83 35.8,33.47 35.8,33.34 35.98,33.15 36.14,33.15 36.38,33.39 36.55,33.39 37.01,32.93 37.01,32.85 36.91,32.75 36.91,32.52 37.14,32.29 37.3,32.29 37.4,32.39 38.57,32.39 38.62,32.44 39.86,32.44 40.26,32.85 40.26,33.04 40.37,33.14 40.91,33.14 41.01,33.04 41.01,32.47 41.29,32.2 41.63,32.2 41.73,32.1 41.73,31.84 41.83,31.74 42.14,31.74 42.24,31.84 42.24,32.1 42.34,32.2 42.65,32.2 42.75,32.1 42.75,31.84 42.85,31.74 43.15,31.74 43.26,31.84 43.26,32.1 43.36,32.2 44.42,32.2 44.96,31.66 45.76,31.66 46.05,31.95 46.74,31.95 47.18,31.51 59.3,31.51 60.68,32.89 60.68,33.51 v1(60.89,33.71)
  BOTTOM w0.089: U1.AK25 36.78,53.47 v1(37.13,53.82)
  BOTTOM w0.102: v1(60.89,33.71) 60.83,33.65 DIMM1.57
M_CHB_DQ31: length 61.1
  TOP w0.102: v1(66.31,33.94) 66.78,33.94 66.98,33.74 v2(66.98,33.62) 66.98,33.34 66.68,33.04 64.55,33.04 64.4,33.19 62.46,33.19 62.02,33.63 62.02,33.87 61.76,34.13 60.63,34.13 60.33,33.82 60.33,33.01 59.16,31.84 47.19,31.84 46.46,32.58 41.63,32.58 41.45,32.76 41.45,33.2 41.28,33.37 36.84,33.37 36.6,33.61 36.6,33.98 36.76,34.13 36.76,34.69 35.59,35.85 35.29,35.85 34.45,36.7 34.45,38.18 33.83,38.8 33.83,51.82 34.3,52.29 35.58,52.29 36.52,53.23 37.17,53.23 v1(37.74,53.8)
  BOTTOM w0.089: v1(37.74,53.8) 37.43,53.49 U1.AL25
  BOTTOM w0.102: DIMM1.58 66.32,33.95 v1(66.31,33.94)
M_CHB_DQ32: length 30
  TOP w0.102: v2(60.83,57.9) 61.27,57.47 61.27,57.3 v1(61.51,57.05)
  IN1 w0.089: 49.81,53.64 48.79,54.65 47.37,54.65 v1(46.71,53.99)
  IN1 w0.127: 49.81,53.64 50.5,52.95 53.82,52.95 54.31,53.43 58.42,53.43 58.55,53.56 58.55,53.89 58.68,54.02 58.93,54.02 59.06,53.89 59.06,53.56 59.19,53.43 59.69,53.43 60.4,54.14 60.4,54.47 60.1,54.78 60.1,55.09 60.4,55.39 60.61,55.39 61.32,54.68 61.71,54.68 62.56,55.53 62.56,56.06 62.33,56.28 61.8,56.28 61.51,56.56 v1(61.51,57.05)
  BOTTOM w0.089: U1.AY23 43.24,54.26 44.21,54.26 44.83,53.64 46.36,53.64 v1(46.71,53.99)
  BOTTOM w0.102: v1(61.51,57.05) 60.91,57.65 DIMM1.129
M_CHB_DQ33: length 30.6
  TOP w0.102: v2(62.82,56.79) 62.55,57.05 v1(62.15,57.05)
  IN1 w0.089: 49.81,53.02 48.36,54.46 47.68,54.46 47.37,54.16 v1(47.37,54.02)
  IN1 w0.127: v1(62.15,57.05) 62.88,57.05 63.48,56.46 63.48,55.94 62.15,54.62 62.15,53.85 61.35,53.05 54.43,53.05 53.97,52.6 50.23,52.6 49.81,53.02
  BOTTOM w0.089: v1(47.37,54.02) 46.81,53.46 44.75,53.46 44.13,54.08 43.58,54.08 43.38,53.88 43.08,53.88 42.92,53.95 42.7,53.95 U1.AW23
  BOTTOM w0.102: DIMM1.131 60.95,58.25 v1(62.15,57.05)
M_CHB_DQ34: length 29.2
  TOP w0.102: v1(62.37,60.99) 62.18,61.18 v2(62.18,61.74)
  IN1 w0.089: v1(45.21,56.1) 45.21,56.33 45.46,56.58 46.37,56.58 46.69,56.89 49.03,56.89 49.25,57.12 49.81,57.12
  IN1 w0.127: 49.81,57.12 50.37,57.12 50.42,57.16 51.78,57.16 51.88,57.07 54.35,57.07 54.65,56.76 57.3,56.76 57.56,57.01 57.94,57.01 58.16,57.23 58.16,58.12 59.82,59.77 60.32,59.77 60.75,60.21 63.12,60.21 63.59,60.68 63.59,60.86 63.46,60.99 v1(62.37,60.99)
  BOTTOM w0.089: U1.AY21 43.25,55.41 44.52,55.41 v1(45.21,56.1)
  BOTTOM w0.102: v1(62.37,60.99) 61.51,61.85 DIMM1.143
M_CHB_DQ35: length 31.3
  TOP w0.102: v2(64.59,61.87) 65.05,61.41 65.17,61.41 v1(65.59,60.99)
  IN1 w0.089: 49.81,56.41 46.72,56.41 46.01,55.7 45.05,55.7 44.65,56.1 v1(44.6,56.1)
  IN1 w0.127: v1(65.59,60.99) 64.09,59.5 61.04,59.5 60.53,58.98 60.03,58.98 58.93,57.88 58.93,56.54 58.68,56.29 57.84,56.29 57.6,56.05 54.36,56.05 54.05,56.35 52.4,56.35 51.82,55.77 51.11,55.77 50.47,56.41 49.81,56.41
  BOTTOM w0.089: U1.AW21 43.07,55.81 43.37,55.81 43.6,55.58 44.45,55.58 44.6,55.74 v1(44.6,56.1)
  BOTTOM w0.102: DIMM1.142 66.14,61.55 v1(65.59,60.99)
M_CHB_DQ36: length 31.9
  TOP w0.102: v1(65.56,57.83) 66.15,58.41 v2(66.8,58.41)
  IN1 w0.089: v1(48.08,53.99) 49.81,52.27
  IN1 w0.127: v1(65.56,57.83) 65.56,57.8 64.58,56.82 64.58,56.54 62.94,54.91 62.94,54.14 61.49,52.7 54.58,52.7 54.12,52.24 49.84,52.24 49.81,52.27
  BOTTOM w0.089: U1.AV23 42.23,53.77 42.88,53.77 43.03,53.7 43.45,53.7 43.65,53.9 44.06,53.9 44.68,53.28 47.37,53.28 47.75,53.66
  BOTTOM w0.102: DIMM1.130 66.64,57.95 66.6,57.99 65.72,57.99 v1(65.56,57.83) ; 47.75,53.66 v1(48.08,53.99)
M_CHB_DQ37: length 31.9
  TOP w0.102: v2(65.38,57.14) 65.38,57.34 v1(64.9,57.83)
  IN1 w0.089: v1(45.67,54.45) 46.34,54.45 46.8,54.91 49.61,54.91 49.81,54.7
  IN1 w0.127: v1(64.9,57.83) 64.49,57.83 64.15,57.48 60.67,57.48 60.43,57.24 60.43,55.92 59.06,54.55 53.77,54.55 53.27,54.04 50.47,54.04 49.81,54.7
  BOTTOM w0.089: v1(45.67,54.45) 45.67,54.47 45.1,55.05 43.04,55.05 42.98,55.08 42.98,55.08 42.88,55.12 42.75,55.12 42.63,55.07 42.6,55.05 42.38,55.05 42.21,55.14 41.99,55.14 41.92,55.07 41.73,55.07 41.64,55.16 41.38,55.16 41.19,54.97 U1.AU23
  BOTTOM w0.102: v1(64.9,57.83) 64.9,57.85 65.37,58.32 66.33,58.32 66.56,58.55 DIMM1.132
M_CHB_DQ38: length 31.2
  TOP w0.102: v2(66.93,60.22) 66.66,60.49 66.66,60.56 v1(66.22,60.99)
  IN1 w0.089: 49.81,56.76 49.66,56.76 49.62,56.72 46.76,56.72 46.15,56.1 v1(45.85,56.1)
  IN1 w0.127: v1(66.22,60.99) 65.73,61.49 64.82,61.49 64.21,60.88 64.21,60.8 63.26,59.85 60.9,59.85 60.4,59.35 59.9,59.35 58.52,57.97 58.52,57.09 58.09,56.66 57.7,56.66 57.45,56.41 54.5,56.41 54.2,56.71 52.25,56.71 51.67,56.13 51.26,56.13 50.62,56.76 49.81,56.76
  BOTTOM w0.089: U1.AV21 42.09,55.41 42.12,55.38 42.43,55.23 42.56,55.23 42.71,55.3 42.93,55.3 42.97,55.28 42.97,55.28 43.03,55.25 43.08,55.23 44.98,55.23 v1(45.85,56.1)
  BOTTOM w0.102: DIMM1.140 66.33,60.95 66.29,60.99 v1(66.22,60.99)
M_CHB_DQ39: length 32.4
  TOP w0.102: v1(61.7,60.99) 61.28,61.41 60.48,61.41 v2(60.28,61.21)
  IN1 w0.089: v1(43.99,56.1) 43.99,56.35 44.18,56.54 45.12,56.54 45.33,56.75 46.3,56.75 46.61,57.07 48.95,57.07 49.35,57.47 49.81,57.47
  IN1 w0.127: v1(61.7,60.99) 61.7,60.64 61.62,60.56 60.6,60.56 60.17,60.13 59.67,60.13 57.63,58.09 57.63,57.92 57.81,57.75 57.81,57.59 57.61,57.4 57.41,57.4 57.13,57.12 56.39,57.12 56.32,57.19 56.32,57.38 56.58,57.64 56.58,57.81 56.49,57.9 55.81,57.9 55.71,57.8 55.71,57.27 55.56,57.12 55.23,57.12 55.1,57.24 55.1,57.77 54.97,57.9 54.67,57.9 54.54,57.78 54.54,57.55 54.42,57.42 54.16,57.42 54.05,57.53 54.05,57.8 53.95,57.9 53.65,57.9 53.53,57.79 53.53,57.55 53.4,57.42 53.09,57.42 52.99,57.52 52.99,57.8 52.88,57.9 52.55,57.9 52.46,57.81 52.46,57.55 52.36,57.45 52.05,57.45 51.97,57.52 51.97,57.75 51.89,57.83 51.44,57.83 51.17,57.56 50.31,57.56 50.23,57.47 49.81,57.47
  BOTTOM w0.089: U1.AU21 41.37,55.41 41.67,55.71 42.01,55.71 42.31,55.76 42.47,55.81 42.81,55.99 43.88,55.99 v1(43.99,56.1)
  BOTTOM w0.102: v1(61.7,60.99) 61.28,61.41 60.88,61.41 60.72,61.25 DIMM1.141
M_CHB_DQ40: length 31.4
  TOP w0.102: v1(61.55,62.76) 61.13,63.17 60.19,63.17 v2(59.97,62.96)
  IN1 w0.089: v1(45.42,57.33) 45.82,57.73 48.58,57.73
  IN1 w0.127: v1(61.55,62.76) 61.55,62.58 61.29,62.32 60.46,62.32 59.61,61.48 59.11,61.48 58.75,61.12 58.5,60.88 58.35,60.88 58.19,61.03 57.79,61.03 57.53,60.78 57.53,60.42 57.66,60.29 57.66,60.05 57.47,59.86 57.05,59.86 56.97,59.78 56.97,59.33 56.89,59.25 56.51,59.25 56.41,59.35 56.41,60.04 56.29,60.16 55.81,60.16 55.68,60.04 55.68,59.83 55.6,59.76 55.16,59.76 55.03,59.89 55.03,60.27 54.91,60.39 54.65,60.39 54.53,60.27 54.53,59.78 54.4,59.66 54.15,59.66 54.02,59.78 54.02,60.16 53.89,60.29 53.64,60.29 53.51,60.16 53.51,59.89 53.38,59.76 53.13,59.76 53,59.89 53,60.16 52.88,60.29 52.62,60.29 52.49,60.16 52.49,59.73 52.37,59.61 52.11,59.61 51.99,59.73 51.99,60.16 51.86,60.29 51.61,60.29 51.48,60.16 51.48,59.89 51.35,59.76 50.9,59.76 50.67,59.53 50.67,59.25 50.37,58.95 49.79,58.95 48.58,57.73
  BOTTOM w0.089: U1.AY19 43.33,56.78 44.86,56.78 v1(45.42,57.33)
  BOTTOM w0.102: v1(61.55,62.76) 61.13,63.17 60.71,63.17 60.59,63.05 DIMM1.147
M_CHB_DQ41: length 32
  TOP w0.102: v2(61.44,63.95) 61.44,63.64 62.18,62.91 v1(62.18,62.76)
  IN1 w0.089: v1(46.03,57.33) 46.37,57.33 46.49,57.45 48.79,57.45 49.81,58.46
  IN1 w0.127: v1(62.18,62.76) 62.18,62.76 62.94,62.76 63.1,62.6 63.1,62.19 62.89,61.98 61.42,61.98 61.41,61.97 60.61,61.97 59.76,61.12 59.26,61.12 57.03,58.89 56.19,58.89 56.06,59.02 56.06,59.28 55.93,59.4 55.68,59.4 55.55,59.28 55.55,59.02 55.43,58.89 55.17,58.89 55.04,59.02 55.04,59.28 54.92,59.4 54.66,59.4 54.54,59.28 54.54,59.02 54.41,58.89 54,58.89 53.87,59.02 53.87,59.28 53.75,59.4 53.06,59.4 52.96,59.3 52.96,59.02 52.83,58.89 52.07,58.89 51.94,59.02 51.94,59.25 51.79,59.4 51.23,59.4 51.11,59.28 51.11,59.05 50.62,58.56 49.91,58.56 49.81,58.46
  BOTTOM w0.089: v1(46.03,57.33) 45.63,56.93 45.27,56.93 44.93,56.59 43.67,56.59 43.37,56.3 43.02,56.3 42.72,56.59 U1.AW19
  BOTTOM w0.102: DIMM1.149 61.29,63.65 v1(62.18,62.76)
M_CHB_DQ42: length 30
  TOP w0.102: v1(61.52,66.41) 61.52,66.05 v2(61.93,65.65)
  IN1 w0.089: 45.46,59.75 45.36,59.75 45.09,59.49 45.09,59.16 45.32,58.93 45.32,58.59 45.01,58.28 44.67,58.28 44.6,58.22 v1(44.59,58.23)
  IN1 w0.127: v1(61.52,66.41) 63.12,66.41 63.25,66.28 63.25,65.96 63.12,65.83 60.34,65.83 58.55,64.04 58.04,64.04 57.59,63.59 56.72,63.59 56.09,62.96 54.33,62.96 53.82,63.47 53.09,63.47 52.48,62.86 50.32,62.86 48.21,60.75 47.68,60.75 47.23,60.29 46,60.29 45.46,59.75
  BOTTOM w0.089: U1.AY17 43.4,57.94 43.56,58.11 43.7,58.11 43.83,58.23 v1(44.59,58.23)
  BOTTOM w0.102: v1(61.52,66.41) 61.11,66.83 60.71,66.83 60.53,66.65 DIMM1.159
M_CHB_DQ43: length 31.2
  TOP w0.102: v2(60.17,65.52) 60.17,65.71 v1(60.88,66.41)
  IN1 w0.089: 46.14,60.81 44.79,59.46 44.79,58.89 44.92,58.77 v1(44.92,58.75)
  IN1 w0.127: v1(60.88,66.41) 60.65,66.18 60.19,66.18 59.17,65.17 58.88,65.17 58.73,65.02 58.73,64.73 58.51,64.51 58.27,64.51 58.12,64.66 58.12,65.02 57.99,65.15 57.56,65.15 57.43,65.02 57.43,64.08 57.3,63.95 56.9,63.95 56.8,64.05 56.8,65.05 56.68,65.17 56.02,65.17 55.82,64.97 55.82,64.45 56.14,64.13 56.14,63.51 55.94,63.31 55.42,63.31 55.27,63.47 55.27,64.18 55.15,64.3 54.74,64.3 54.64,64.2 54.64,63.78 54.51,63.64 54.14,63.64 53.97,63.82 52.95,63.82 52.34,63.21 50.17,63.21 48.03,61.08 47.51,61.08 47.25,60.81 46.14,60.81
  BOTTOM w0.089: U1.AW17 42.6,58.05 42.7,58.05 42.78,58.09 43.08,58.23 43.19,58.28 43.63,58.28 43.97,58.63 44.46,58.63 44.59,58.75 v1(44.92,58.75)
  BOTTOM w0.102: DIMM1.157 60.52,66.05 v1(60.88,66.41)
M_CHB_DQ44: length 31.6
  TOP w0.089: v1(42.23,56.16) 42.61,56.53 v2(42.88,56.53)
  IN1 w0.089: 49.81,58.11 49.71,58.11 48.87,57.27 48.72,57.27 46.56,57.27 46.22,56.93 45.16,56.93 44.95,56.72 44.05,56.72 43.48,56.16 v1(42.23,56.16)
  IN1 w0.127: v1(66.31,62.76) 66.52,62.76 67.03,62.25 67.03,62.04 66.73,61.74 66.55,61.74 66.17,62.12 64.26,62.12 63.77,61.63 61.57,61.63 61.55,61.61 60.75,61.61 59.91,60.77 59.41,60.77 57.18,58.54 51.76,58.54 51.68,58.46 51.16,58.46 50.9,58.21 50.07,58.21 49.96,58.11 49.81,58.11
  BOTTOM w0.089: v1(42.23,56.16) 42.23,56.16 42.21,56.19 42.21,56.34 42.15,56.39 U1.AV19
  BOTTOM w0.102: v1(66.31,62.76) 67.69,62.76 DIMM1.146
M_CHB_DQ45: length 33.3
  TOP w0.089: v1(44.7,57.26) 43.75,58.21 v2(43.59,58.21)
  IN1 w0.089: v1(44.7,57.26) 44.7,57.36 45.87,58.53 46.13,58.53 46.67,59.07 46.94,59.07 47.06,59.19
  IN1 w0.127: v1(65.68,62.76) 66.07,63.15 66.07,63.82 65.63,64.25 60.27,64.25 58.99,62.98 58.48,62.98 58.04,62.53 57.16,62.53 56.53,61.89 53.9,61.89 53.8,61.79 50.8,61.79 48.54,59.53 48.19,59.53 47.86,59.19 47.06,59.19
  BOTTOM w0.089: v1(44.7,57.26) 44.4,56.96 42.01,56.96 41.97,57 41.72,57 41.42,56.7 U1.AU19
  BOTTOM w0.102: v1(65.68,62.76) 66.27,63.35 DIMM1.148
M_CHB_DQ46: length 31.8
  IN1 w0.089: 47.26,59.57 47.04,59.57 46.78,59.31 46.57,59.31 46.19,58.93 v1(45.96,58.93)
  IN1 w0.127: 47.26,59.57 47.71,59.57 48.06,59.91 48.42,59.91 50.65,62.15 53.65,62.15 53.75,62.25 56.38,62.25 57.02,62.88 57.89,62.88 58.34,63.33 58.84,63.33 60.63,65.12 63.93,65.12 64.19,65.37 v1(64.19,66.41)
  BOTTOM w0.089: U1.AV17 41.98,57.94 42.3,58.26 42.73,58.26 42.93,58.36 43,58.39 43.1,58.44 43.16,58.47 43.54,58.47 43.88,58.8 44.39,58.8 44.76,59.17 45.07,59.17 45.43,58.82 45.85,58.82 v1(45.96,58.93) 46.28,58.93 46.28,58.93 46.86,58.93 v2(47.3,58.49)
  BOTTOM w0.102: v1(64.19,66.41) 64.25,66.35 DIMM1.158
M_CHB_DQ47: length 32.4
  TOP w0.089: v2(44.91,59.73) 45.09,59.73 v1(45.49,59.33)
  IN1 w0.089: v1(45.49,59.33) 45.85,59.68 46.71,59.68 46.97,59.94
  IN1 w0.127: 46.97,59.94 47.38,59.94 47.78,60.34 48.35,60.34 50.5,62.5 52.63,62.5 53.24,63.11 53.67,63.11 54.18,62.6 56.23,62.6 56.87,63.24 57.74,63.24 58.19,63.69 58.7,63.69 59.42,64.41 60.48,65.47 63.27,65.47 63.7,65.91 63.7,66.57 64.29,67.15 v1(65.76,67.15)
  BOTTOM w0.089: U1.AU17 41.47,58.22 41.65,58.22 41.87,58.44 41.87,58.71 42.04,58.88 42.65,58.88 42.69,58.92 42.94,58.92 42.97,58.89 43.37,58.89 43.54,59.06 43.54,59.14 44,59.6 45.22,59.6 v1(45.49,59.33)
  BOTTOM w0.102: DIMM1.160 65.96,66.95 v1(65.76,67.15)
M_CHB_DQ48: length 37.7
  TOP w0.102: v2(62.22,70.65) v1(61.52,71.36)
  IN1 w0.089: v1(40.41,55.66) 40.41,55.67 40.69,55.95 40.69,56.76 42.9,58.97 42.9,59.75 43.68,60.52 43.95,60.52 45.14,61.71 45.14,62.81 46.6,64.27
  IN1 w0.127: v1(61.52,71.36) 61.52,71.04 61.41,70.93 60.05,70.93 59.97,70.85 59.97,70.5 59.82,70.35 59.51,70.35 59.36,70.5 59.36,70.96 59.23,71.09 57.82,71.09 56.98,70.25 56.39,70.25 56.29,70.15 56.29,69.65 56.18,69.54 55.75,69.54 55.51,69.3 55.16,69.3 55.04,69.41 55.04,69.54 54.96,69.62 54.44,69.62 54.21,69.38 53.75,69.38 53.52,69.62 53.06,69.62 52.96,69.72 52.8,69.72 52.53,69.45 52.53,69.33 52.71,69.16 52.71,68.93 52.48,68.7 52.48,68.68 51.96,68.17 51.46,68.17 50.93,68.7 50.7,68.7 50.48,68.48 50.48,68.33 50.8,68.01 50.8,67.94 50.55,67.68 50.37,67.68 49.99,68.07 49.83,68.07 46.6,64.84 46.6,64.27
  BOTTOM w0.089: U1.AR21 40.37,55.71 40.4,55.71 40.41,55.7 v1(40.41,55.66)
  BOTTOM w0.102: v1(61.52,71.36) 61.52,71.37 60.84,72.05 DIMM1.177
M_CHB_DQ49: length 38.7
  TOP w0.102: v2(63.45,67.89) v1(63.96,68.39)
  IN1 w0.089: v1(40.4,54.63) 40.49,54.63 41.23,55.36 41.23,56.5 43.44,58.71 43.44,59.5 43.9,59.96 44.19,59.96 46.4,62.17 46.4,62.18
  IN1 w0.127: 46.4,62.18 46.57,62.35 46.95,62.35 50.71,66.11 51.86,66.11 52.34,65.63 52.68,65.63 52.86,65.8 52.86,66.94 53.43,67.51 59.1,67.51 60.22,68.62 61.25,68.62 61.61,68.98 62.99,68.98 63.55,69.54 63.86,69.54 64.16,69.23 64.16,68.6 v1(63.96,68.39)
  BOTTOM w0.089: U1.AR22 40.24,54.89 40.24,54.79 40.39,54.63 v1(40.4,54.63)
  BOTTOM w0.102: v1(63.96,68.39) 63.96,68.41 64.67,69.12 66,69.12 66.37,68.75 DIMM1.166
M_CHB_DQ50: length 40.9
  TOP w0.089: v2(37.77,55.36) 37.39,55.36 v1(37.11,55.64)
  IN1 w0.089: 45.87,65.1 45.87,64.73 44.35,63.22 44.35,62.31 43.77,61.73 43.77,61.12 42.55,59.89 42.55,59.11 40.54,57.11 38.13,57.11 37.51,56.5 37.51,56.05 v1(37.11,55.64)
  IN1 w0.127: v1(63.55,71.37) 62.89,71.37 62.46,71.8 57.53,71.8 56.68,70.96 53.04,70.96 52,69.92 50.85,69.92 50.14,69.21 49.97,69.21 45.87,65.1
  BOTTOM w0.089: U1.AL21 37.43,55.96 v1(37.11,55.64)
  BOTTOM w0.102: DIMM1.174 66.66,71.15 66.4,70.88 64.04,70.88 v1(63.55,71.37)
M_CHB_DQ51: length 41.8
  TOP w0.102: v1(60.88,67.84) 59.84,68.87 v2(59.84,69.05)
  IN1 w0.089: 46.53,61.76 44.37,59.6 44.04,59.6 43.79,59.35 43.79,58.57 41.58,56.35 41.58,54.99 40.64,54.05 40.11,54.05 39.94,54.22 38.85,54.22 v1(38.4,54.67)
  IN1 w0.127: v1(60.88,67.84) 60.88,67.51 60.78,67.4 60.01,67.4 59.4,66.79 58.93,66.79 58.8,66.67 58.8,66.28 58.68,66.16 58.41,66.16 58.28,66.29 58.28,66.67 58.15,66.79 57.9,66.79 57.77,66.67 57.77,66.29 57.64,66.16 57.39,66.16 57.26,66.29 57.26,66.67 57.14,66.79 56.88,66.79 56.75,66.67 56.75,66.29 56.63,66.16 56.37,66.16 56.25,66.29 56.25,66.67 56.12,66.79 55.87,66.79 55.74,66.67 55.74,66.26 55.61,66.13 55.36,66.13 55.23,66.26 55.23,66.67 55.1,66.79 54.85,66.79 54.72,66.67 54.72,65.99 54.48,65.75 54.28,65.75 54.15,65.88 54.15,66.65 54.01,66.79 53.72,66.79 53.57,66.64 53.57,65.27 53.19,64.89 52.61,64.89 51.95,64.23 51.44,64.23 51.32,64.36 51.32,65.14 51.19,65.27 50.93,65.27 50.81,65.14 50.81,64.36 50.68,64.23 49.84,64.23 47.37,61.76 46.53,61.76
  BOTTOM w0.089: v1(38.4,54.67) 38.4,54.78 U1.AM22
  BOTTOM w0.102: DIMM1.163 60.87,67.85 v1(60.88,67.84)
M_CHB_DQ52: length 39.9
  TOP w0.089: v1(39.06,54.67) 39.38,54.67 v2(39.68,54.97)
  IN1 w0.089: v1(39.06,54.67) 39.79,54.67 40.23,54.23 40.56,54.23 41.4,55.07 41.4,56.43 43.61,58.64 43.61,59.43 43.97,59.78 44.27,59.78 46.51,62.02 47.12,62.02
  IN1 w0.127: 47.12,62.02 50.85,65.75 51.71,65.75 52.22,65.24 53.04,65.24 53.21,65.42 53.21,66.79 53.58,67.15 59.25,67.15 60.37,68.27 61.4,68.27 61.75,68.62 62.79,68.62 63.57,67.84 65.15,67.84 65.38,68.06 v1(65.38,68.7)
  BOTTOM w0.089: U1.AN22 38.73,54.99 39.06,54.66 v1(39.06,54.67)
  BOTTOM w0.102: v1(65.38,68.7) 65.93,68.15 DIMM1.164
M_CHB_DQ53: length 38.9
  TOP w0.102: v1(60.89,71.36) 60.89,71.27 v2(60.41,70.8)
  IN1 w0.089: v1(39.71,55.66) 39.29,56.08 38.23,56.08 37.96,56.35 37.96,56.69 38.2,56.93 40.61,56.93 42.73,59.04 42.73,59.82 43.6,60.7 43.87,60.7 44.57,61.4 44.57,63.19 46.31,64.92
  IN1 w0.127: 46.31,64.92 46.31,65.04 50.02,68.75 50.22,68.75 50.52,69.05 51.08,69.05 51.54,68.6 51.82,68.6 52.01,68.79 52.01,69.05 51.89,69.16 51.89,69.31 52.8,70.22 53.01,70.22 53.26,69.97 53.52,69.97 53.8,70.25 53.8,70.46 53.95,70.6 54.25,70.6 54.37,70.48 54.37,70.12 54.53,69.97 54.78,69.97 54.88,70.07 54.88,70.48 55.01,70.6 55.26,70.6 55.39,70.48 55.39,70.12 55.54,69.97 55.8,69.97 55.9,70.07 55.9,70.48 56.03,70.6 56.83,70.6 57.67,71.44 60.03,71.44 60.12,71.36 v1(60.89,71.36)
  BOTTOM w0.089: v1(39.71,55.66) 39.71,55.66 39.5,55.87 39.5,55.93 U1.AP21
  BOTTOM w0.102: DIMM1.175 60.81,71.45 60.89,71.37 v1(60.89,71.36)
M_CHB_DQ54: length 40.5
  IN1 w0.089: v1(37.11,56.48) 37.67,57.04 37.75,57.04 38.01,57.31 38.01,57.79 38.96,58.74 40.65,58.74 41.07,59.16 41.07,59.54 41.12,59.59 41.12,59.78 41.46,60.12 42.3,60.12 43.59,61.42 43.59,61.8 44.17,62.38 44.17,63.29 45.67,64.79 45.67,65.41 48.19,67.93
  IN1 w0.127: 48.19,67.93 49.85,69.59 50.02,69.59 50.98,70.55 51.31,70.55 51.59,70.27 51.84,70.27 52.2,70.63 52.2,70.85 52.67,71.32 56.54,71.32 57.38,72.16 62.66,72.16 62.95,71.87 63.87,71.87 64.19,71.55 v1(64.19,71.37)
  BOTTOM w0.089: v1(37.11,56.48) 37.11,56.39 U1.AK21
  BOTTOM w0.102: v1(64.19,71.37) 64.24,71.32 64.92,71.32 65.56,71.95 66.43,71.95 66.63,71.75 DIMM1.176
M_CHB_DQ55: length 42
  TOP w0.102: v1(61.52,67.84) 60.99,67.3 v2(60.4,67.3)
  IN1 w0.089: 46.59,61.54 44.61,59.56 44.61,59.04 44.38,58.8 44.31,58.8 41.83,56.32 41.83,55.99 41.86,55.96 41.86,55.02 40.24,53.4 36.31,53.4 36.05,53.66 36.05,53.99 36.73,54.68 v1(37.11,54.68)
  IN1 w0.127: 46.59,61.54 47.62,61.54 49.92,63.85 52.07,63.85 52.73,64.51 54.03,64.51 54.46,64.94 54.89,64.94 55.76,65.8 58.91,65.8 60.15,67.05 62.51,67.05 62.89,67.43 62.89,68.01 62.64,68.27 61.95,68.27 v1(61.52,67.84)
  BOTTOM w0.089: U1.AK22 36.78,55.01 v1(37.11,54.68)
  BOTTOM w0.102: DIMM1.165 60.91,68.45 v1(61.52,67.84)
M_CHB_DQ56: length 40.8
  IN3 w0.089: v1(38.99,56.51) 39.37,56.13 41.61,56.13 43.81,58.33 43.81,59.37 44.88,60.44 46.03,60.44
  IN3 w0.102: 46.03,60.44 46.51,60.44 47.1,61.04 47.1,61.18 46.83,61.46 46.83,61.6 47.04,61.82 47.19,61.82 47.46,61.54 47.61,61.54 47.86,61.79 47.86,61.94 47.53,62.26 47.53,62.41 47.68,62.55 47.82,62.55 48.15,62.22 48.29,62.22 48.44,62.37 48.44,62.51 48.11,62.84 48.11,62.98 48.25,63.13 48.4,63.13 48.72,62.8 48.87,62.8 49.01,62.94 49.01,63.09 48.68,63.41 48.68,63.56 48.83,63.7 48.97,63.7 49.3,63.37 49.44,63.37 49.59,63.52 49.59,63.66 49.26,63.99 49.26,64.13 49.4,64.28 49.55,64.28 49.87,63.95 50.02,63.95 51.39,65.32 52.48,65.32 53.76,66.6 54.42,66.6 55.97,68.15 56.74,68.15 60.38,71.78 61.59,71.78 v1(62.45,72.64)
  BOTTOM w0.089: U1.AN20 38.73,56.75 38.99,56.5 v1(38.99,56.51)
  BOTTOM w0.102: v1(62.45,72.64) 62.03,72.22 61.64,72.22 61.38,72.48 61.38,72.83 60.96,73.25 DIMM1.181
M_CHB_DQ57: length 41.4
  TOP w0.089: v1(40.21,56.53) 40.77,55.97 40.84,55.97 v2(41.4,55.41)
  IN3 w0.089: 49.91,64.63 49.03,64.63 ; v1(40.21,56.53) 41.73,56.53 43.63,58.43 43.63,59.44 45.06,60.87
  IN3 w0.102: v1(61.81,72.64) 61.36,72.19 60.21,72.19 56.58,68.56 55.8,68.56 54.26,67.01 53.59,67.01 52.31,65.73 51.22,65.73 50.13,64.63 49.91,64.63 ; 45.06,60.87 45.06,61.41 45.41,61.76 45.53,61.76 46.31,60.98 46.46,60.98 46.6,61.12 46.6,61.29 45.84,62.05 45.84,62.19 45.99,62.34 46.13,62.34 46.48,61.98 46.63,61.98 46.77,62.13 46.77,62.27 46.42,62.62 46.42,62.77 46.56,62.91 46.71,62.91 47.06,62.56 47.2,62.56 47.35,62.7 47.35,62.85 46.99,63.2 46.99,63.34 47.14,63.49 47.28,63.49 47.63,63.13 47.78,63.13 47.92,63.28 47.92,63.42 47.57,63.77 47.57,63.92 47.71,64.06 47.86,64.06 48.21,63.71 48.35,63.71 48.5,63.85 48.5,64 48.14,64.35 48.14,64.49 48.29,64.63 49.03,64.63
  BOTTOM w0.089: v1(40.21,56.53) 40.03,56.71 U1.AR20
  BOTTOM w0.102: DIMM1.183 60.97,73.85 61.81,73.01 v1(61.81,72.64)
M_CHB_DQ58: length 42.2
  TOP w0.102: v2(60.87,75.85) v1(61.61,75.85)
  IN3 w0.089: v1(36.33,57.65) 36.33,57.91 37.18,58.76 41.91,58.76 42.55,59.4 42.55,61.74 44.02,63.21 44.02,64 44.4,64.38 44.4,64.79 44.58,64.97 44.89,64.97 45.26,64.6 45.38,64.6 45.51,64.73 45.51,64.85 45.25,65.11 45.25,65.23 45.42,65.4 46.2,65.4 47.7,66.9 48.21,66.9
  IN3 w0.102: 48.21,66.9 49.64,68.32 50.56,68.32 51.59,69.35 51.59,69.96 53.27,71.64 53.48,71.64 53.9,71.21 54,71.21 54.23,71.45 54.23,71.54 53.82,71.95 53.82,72.19 53.98,72.34 53.98,72.34 54.21,72.58 54.72,73.08 54.93,73.08 55.12,72.89 55.93,72.89 56.12,73.08 56.51,73.08 56.83,72.76 56.98,72.76 60.07,75.85 v1(61.61,75.85)
  BOTTOM w0.089: v1(36.33,57.65) 36.63,57.96 U1.AK18
  BOTTOM w0.102: v1(61.61,75.85) 61.61,76.22 60.98,76.85 DIMM1.193
M_CHB_DQ59: length 42.8
  TOP w0.102: v2(63.94,76.28) 63.16,76.28 62.73,75.85 v1(62.24,75.85)
  IN3 w0.089: 44.63,63.52 42.88,61.76 42.88,60.04 42.73,59.89 42.73,59.32 41.98,58.58 37.79,58.58 37.61,58.41 v1(37.61,57.48)
  IN3 w0.102: v1(62.24,75.85) 62.24,75.47 62.13,75.35 60.16,75.35 57.01,72.2 56.19,72.2 55.91,72.48 54.69,72.48 54.38,72.17 54.38,71.97 54.81,71.54 54.81,71.32 54.1,70.6 53.87,70.6 53.57,70.91 53.57,70.91 53.49,70.98 53.19,70.98 52,69.79 52,69.18 50.78,67.96 50.17,67.96 48.65,66.44 47.55,66.44 45.15,64.04 45.01,64.04 44.79,64.25 44.65,64.25 44.51,64.11 44.51,63.96 44.72,63.75 44.72,63.61 44.63,63.52
  BOTTOM w0.089: U1.AL18 37.43,57.67 v1(37.61,57.48)
  BOTTOM w0.102: DIMM1.191 60.54,76.25 61.36,75.43 61.83,75.43 v1(62.24,75.85)
M_CHB_DQ60: length 41.8
  IN3 w0.089: 50.11,62.77 47.71,60.38 47.71,59.61 46.64,58.54 46.14,58.54 46.13,58.53 45.61,58.53 44.91,57.83 43.81,57.83 43.26,57.27 43.26,56.36 41.98,55.08 37.28,55.08 37.25,55.1 36.97,55.1 36.48,55.59 v1(36.48,56.58)
  IN3 w0.102: 50.11,62.77 51.84,64.51 52.81,64.51 54.1,65.79 54.76,65.79 56.31,67.34 57.08,67.34 60.19,70.45 62.43,70.45 63.01,71.03 63.01,71.42 63.38,71.79 64.16,71.79 64.56,72.18 65.26,72.18 65.56,72.48 v1(65.56,72.6)
  BOTTOM w0.089: v1(36.48,56.58) 36.48,56.71 U1.AK20
  BOTTOM w0.102: DIMM1.180 66.57,72.95 66.43,73.09 66.42,73.09 66.41,73.1 66.07,73.1 66.06,73.09 66.04,73.09 65.56,72.62 v1(65.56,72.6)
M_CHB_DQ61: length 41.3
  IN3 w0.089: v1(38.36,56.52) 38.36,56.51 38.01,56.16 38.01,55.49 38.24,55.26 41.9,55.26 43.08,56.43 43.08,57.35 44.35,58.62 44.35,58.77 44.86,59.28 44.86,59.43 45.29,59.86 46,59.86 46.59,59.28 46.89,59.28 47.12,59.5 47.12,59.71 46.89,59.94 46.89,60.13
  IN3 w0.102: 46.89,60.13 51.67,64.91 52.65,64.91 53.93,66.2 54.59,66.2 56.14,67.75 56.91,67.75 60.04,70.87 62.27,70.87 62.6,71.2 62.6,71.59 63.21,72.2 63.93,72.2 64.35,72.62 64.84,72.62 v1(64.85,72.6)
  BOTTOM w0.089: U1.AM20 38.08,56.79 v1(38.36,56.52)
  BOTTOM w0.102: DIMM1.182 65.78,73.55 64.85,72.62 v1(64.85,72.6)
M_CHB_DQ62: length 38.7
  TOP w0.089: v1(40.29,57.52) 40.77,57.03 v2(40.77,57.03)
  IN3 w0.089: 49.74,66.38 48.96,65.6 47.63,65.6 43.59,61.56 43.59,60.15 43.08,59.65 43.08,59.1 41.5,57.52 v1(40.29,57.52)
  IN3 w0.102: 49.74,66.38 50.55,67.19 51.15,67.19 52.92,68.96 52.92,69.36 53.18,69.61 54.26,69.61 55.25,70.6 56.55,70.6 60.05,74.1 63.11,74.1 64.47,75.46 65.3,75.46 65.51,75.25 65.76,75.25 65.91,75.4 65.91,75.63 v1(65.66,75.89)
  BOTTOM w0.089: U1.AR18 40.29,57.7 v1(40.29,57.52)
  BOTTOM w0.102: v1(65.66,75.89) 66.32,76.55 DIMM1.192
M_CHB_DQ63: length 40.7
  TOP w0.102: v2(66.83,76.36) 65.47,76.36 v1(65,75.89)
  IN3 w0.089: 49.45,66.67 48.84,66.06 47.73,66.06 43.18,61.51 43.18,60 42.9,59.72 42.9,59.18 42.13,58.4 39.82,58.4 39.68,58.26 v1(39.68,57.54)
  IN3 w0.102: v1(65,75.89) 64.32,75.89 63.38,74.95 60.32,74.95 56.39,71.01 55.91,71.01 55.7,71.21 55.28,71.21 54.09,70.02 53.01,70.02 53,70.01 53,70.01 52.52,69.53 52.52,69.52 52.44,69.45 52.44,69.05 50.98,67.59 50.38,67.59 49.45,66.67
  BOTTOM w0.089: v1(39.68,57.54) 39.57,57.65 39.57,57.77 U1.AP18
  BOTTOM w0.102: v1(65,75.89) 66.26,77.15 DIMM1.194
M_CHB_DQS0: length 50.6
  TOP w0.102: v1(64.11,21.84) 64.11,21.22 63.86,20.97 62.73,20.97 62.17,21.53 60.85,21.53 58.79,23.59 54,23.59 52.17,25.42 51.59,25.42 51.28,25.72 51.28,26.2 v1(51.13,26.35)
  BOTTOM w0.089: 47.75,46.91 47.73,46.93 46.79,46.93 44.59,49.13 43.63,49.13 43.44,49.32 43.08,49.32 42.92,49.24 42.71,49.24 42.56,49.32 42.13,49.32 41.74,49.71 U1.AV30
  BOTTOM w0.102: 51.13,27.04 v2(50.84,27.04) ; 51.13,27.04 51.13,27.46 49.81,28.78 49.81,45.35 48.25,46.91 47.75,46.91 ; 51.13,27.04 v1(51.13,26.35) ; v1(64.11,21.84) 64.11,21.52 65.47,20.16 66.55,20.16 66.56,20.15 DIMM1.12
M_CHB_DQS0#: length 50.8
  TOP w0.102: v1(63.47,21.84) 63.9,21.41 63.9,21.31 63.77,21.18 62.82,21.18 62.26,21.73 60.93,21.73 58.87,23.79 54.08,23.79 52.26,25.62 51.67,25.62 51.49,25.81 51.49,26.07 v1(51.77,26.35)
  BOTTOM w0.089: U1.AW30 42.17,49.55 42.22,49.49 42.6,49.49 42.75,49.42 42.88,49.42 43.04,49.49 43.52,49.49 43.71,49.3 44.67,49.3 46.86,47.11 47.75,47.11 47.75,47.11
  BOTTOM w0.102: DIMM1.10 66.62,19.55 66.22,19.96 65.38,19.96 63.93,21.41 63.9,21.41 v1(63.47,21.84) ; 47.75,47.11 48.33,47.11 50.01,45.43 50.01,29.33 ; 50.01,29.33 50.01,28.86 51.33,27.54 51.33,26.78 v1(51.77,26.35) ; 50.01,29.33 v2(50.31,29.33)
M_CHB_DQS1: length 48.5
  TOP w0.102: v1(57.46,28.21) 57.33,28.34 57.33,28.44 57.51,28.62 58.73,28.62 58.8,28.54 58.8,28.44 59.01,28.24 59.86,28.24 60.83,27.26 61.52,27.26 61.7,27.44 61.7,27.87 61.87,28.04 62.19,28.04 62.36,27.87 62.36,27.46 62.56,27.26 62.56,27.09 62.47,26.99 62.21,26.99 62.13,26.92 v1(62.13,26.65)
  BOTTOM w0.089: 47.75,50.8 45.75,50.8 44.97,51.57 44.49,51.57 44.14,51.92 43.04,51.92 42.88,51.85 42.75,51.85 42.6,51.92 42.23,51.92 42.17,51.99 U1.AW26
  BOTTOM w0.102: DIMM1.29 60.32,25.25 60.56,25.01 60.64,25.01 61.03,25.39 62.05,25.39 62.56,25.91 62.56,26.05 62.49,26.13 61.98,26.13 61.88,26.23 61.88,26.4 v1(62.13,26.65) ; 53.7,31.95 53.7,31.34 55.12,29.91 56.59,29.91 57.1,29.41 57.1,28.57 v1(57.46,28.21) ; 53.7,31.95 v2(53.99,31.95) ; 53.7,31.95 53.7,46.96 49.86,50.8 47.75,50.8
M_CHB_DQS1#: length 48.7
  TOP w0.102: v1(62.76,26.65) 62.76,27.34 62.57,27.54 62.57,27.95 62.28,28.24 61.78,28.24 61.5,27.96 61.5,27.53 61.43,27.46 60.92,27.46 59.94,28.44 59.09,28.44 59.01,28.52 59.01,28.63 58.81,28.82 57.42,28.82 v1(56.81,28.21)
  BOTTOM w0.089: U1.AV26 41.66,51.99 41.89,51.99 42.13,51.75 42.56,51.75 42.71,51.67 42.92,51.67 43.08,51.75 44.07,51.75 44.42,51.4 44.9,51.4 45.67,50.62 47.64,50.62 47.67,50.59 47.75,50.59
  BOTTOM w0.102: 56.08,29.71 55.04,29.71 53.49,31.25 53.49,46.88 49.78,50.59 47.75,50.59 ; 56.08,29.71 56.51,29.71 56.9,29.32 56.9,28.54 56.81,28.45 v1(56.81,28.21) ; 56.08,29.71 v2(56.08,29.42) ; DIMM1.27 60.58,24.65 61.11,25.19 62.13,25.19 62.76,25.82 v1(62.76,26.65)
M_CHB_DQS2: length 55.1
  IN1 w0.089: v1(38.39,50.93) 38.41,50.92 38.41,50.56 38.37,50.52 37.81,50.52 37.48,50.19 37.48,49.9 37.25,49.67 36.67,49.67 36.54,49.53 36.08,49.53 35.67,49.12 35.67,46.17 35.49,45.99 35.1,45.99 34.67,45.56 34.67,41.32 34.98,41.01 36.3,41.01 36.49,40.82 37.33,40.82 37.63,40.52 37.63,40.44 37.63,40.28 37.67,40.24 37.67,40.22 37.68,40.21
  IN1 w0.127: 37.68,40.21 38.05,39.83 38.05,39.81 38.05,39.81 38.78,39.81 39.09,39.5 39.09,39.28 39.82,38.56 39.82,38.33 40.2,37.95 41.01,37.95 41.01,37.95 41.75,37.22 43.35,37.22 44.1,37.96 47.7,37.96 48.38,37.28 58.28,37.28 58.28,37.28 58.41,37.28 58.88,36.8 58.88,36.62 58.7,36.44 58.7,36.12 59.1,35.72 59.52,35.72 59.66,35.85 59.84,35.85 60.82,34.87 63.37,34.87 63.72,35.22 63.81,35.22 64.11,34.92 64.11,34.83 63.66,34.38 63.54,34.38 v1(63.1,33.94)
  BOTTOM w0.102: v1(63.1,33.94) 63.35,33.69 63.35,33.55 61.81,32.01 61.81,31.04 61.19,30.42 60.86,30.42 60.63,30.65 DIMM1.47 ; v1(38.39,50.93) 38.41,50.94 38.41,51.33 38.34,51.4 U1.AM28
M_CHB_DQS2#: length 55.2
  IN1 w0.089: 37.83,40.36 37.82,40.37 37.82,40.58 37.4,41 36.56,41 36.37,41.19 35.05,41.19 34.85,41.39 34.85,45.49 35.18,45.81 35.56,45.81 35.84,46.1 35.84,49.04 36.15,49.35 36.61,49.35 36.75,49.49 37.32,49.49 37.66,49.83 37.66,50.12 37.89,50.35 38.44,50.35 v1(39.07,50.97)
  IN1 w0.127: 37.83,40.36 38.15,40.04 38.88,40.04 39.32,39.6 39.32,39.38 40.05,38.65 40.05,38.43 40.29,38.18 41.09,38.18 41.1,38.17 41.23,38.04 41.23,38.04 41.84,37.43 43.26,37.43 44.01,38.18 47.79,38.18 48.47,37.5 49.46,37.5 49.47,37.51 58.37,37.51 58.37,37.51 58.5,37.51 59.11,36.9 59.11,36.53 58.93,36.34 58.93,36.22 59.2,35.95 59.43,35.95 59.56,36.08 59.93,36.08 60.92,35.09 63.27,35.09 63.63,35.45 63.91,35.45 64.34,35.02 64.34,34.74 63.73,34.13 v1(63.73,33.94)
  BOTTOM w0.102: v1(63.73,33.94) 63.55,33.76 63.55,33.46 62.02,31.93 62.02,30.96 61.27,30.22 60.78,30.22 60.62,30.05 DIMM1.45 ; v1(39.07,50.97) 38.86,51.17 38.86,51.26 U1.AN28
M_CHB_DQS3: length 59.8
  TOP w0.102: 67.57,35.37 67.4,35.54 66.35,35.54 66.3,35.6 v1(66.3,35.87) ; 67.57,35.37 v2(67.79,35.6) ; 67.57,35.37 67.63,35.31 67.63,34.83 67.38,34.58 62.64,34.58 62.15,35.07 60.18,35.07 59.36,34.25 59.36,33.71 58.46,32.81 48.15,32.81 47.5,33.47 47.5,33.48 47.15,33.83 43.48,33.83 43.16,34.15 43.16,34.38 42.41,35.13 37.59,35.13 37.16,35.56 37.16,35.91 37.03,36.04 36.86,36.04 36.4,36.5 36.4,36.76 34.21,38.95 34.21,49.78 34.94,50.51 34.94,50.79 35.71,51.56 35.71,52.15 36.6,53.04 37.47,53.04 37.84,53.41 37.96,53.41 v1(38.38,53.83)
  BOTTOM w0.089: v1(38.38,53.83) 38.38,53.6 U1.AM25
  BOTTOM w0.102: DIMM1.64 66.42,35.75 v1(66.3,35.87)
M_CHB_DQS3#: length 59.9
  TOP w0.102: v1(38.4,52.9) 38.4,53.12 38.3,53.22 37.92,53.22 37.55,52.85 36.68,52.85 35.9,52.07 35.9,51.48 35.13,50.71 35.13,50.43 34.4,49.7 34.4,39.03 36.59,36.84 36.59,36.57 36.94,36.23 37.11,36.23 37.35,35.99 37.35,35.64 37.66,35.32 42.48,35.32 43.35,34.46 43.35,34.23 43.56,34.02 47.23,34.02 47.69,33.56 47.69,33.54 48.22,33.01 58.37,33.01 59.16,33.8 59.16,34.33 60.1,35.27 62.23,35.27 62.72,34.78 65.41,34.78 ; 65.41,34.78 67.3,34.78 67.43,34.91 67.43,35.23 67.32,35.33 66.2,35.33 v1(65.66,35.87) ; 65.41,34.78 v2(65.41,35.07)
  BOTTOM w0.089: U1.AN25 38.4,52.97 v1(38.4,52.9)
  BOTTOM w0.102: v1(65.66,35.87) 66.38,35.15 DIMM1.62
M_CHB_DQS4: length 29.6
  IN1 w0.089: 49.81,55.54 49.78,55.57 46.87,55.57 v1(46.56,55.26)
  IN1 w0.127: 49.81,55.54 50.12,55.54 50.98,54.68 52.2,54.68 52.63,55.11 52.63,55.35 52.78,55.49 53.28,55.49 53.58,55.19 58.8,55.19 59.79,56.18 59.79,57.52 60.39,58.12 61.94,58.12 62.18,58.36 62.18,58.62 v4(62.42,58.86)
  BOTTOM w0.089: v1(46.56,55.26) 46.56,54.47 45.92,53.84 44.88,53.84 44.27,54.45 43.08,54.45 42.92,54.37 42.71,54.37 42.56,54.45 42.24,54.45 41.89,54.64 41.74,54.72 U1.AV22
  BOTTOM w0.102: DIMM1.137 61.74,60.05 62.33,59.45 62.33,59.17 62.42,59.08 v4(62.42,58.86)
M_CHB_DQS4#: length 29.8
  IN1 w0.089: v1(45.9,55.26) 46.3,55.66 46.71,55.66 46.8,55.75 49.79,55.75 49.81,55.77
  IN1 w0.127: v1(61.66,58.86) 61.95,58.56 61.95,58.46 61.84,58.35 60.29,58.35 59.56,57.62 59.56,56.28 58.7,55.41 53.68,55.41 53.37,55.72 52.68,55.72 52.4,55.44 52.4,55.2 52.1,54.91 51.07,54.91 50.21,55.77 49.81,55.77
  BOTTOM w0.089: U1.AW22 42.38,54.63 42.6,54.63 42.71,54.57 42.75,54.55 42.88,54.55 43.04,54.63 44.34,54.63 44.95,54.01 45.85,54.01 46.38,54.55 46.38,54.86 46.31,54.93 46.03,54.93 45.9,55.06 v1(45.9,55.26)
  BOTTOM w0.102: DIMM1.135 60.76,59.45 60.81,59.5 60.81,59.78 60.87,59.85 61.65,59.85 62.13,59.37 62.13,59.22 62.06,59.16 61.71,59.16 61.66,59.11 v1(61.66,58.86)
M_CHB_DQS5: length 30.2
  IN1 w0.089: 48.27,58.6 48.26,58.59 48.23,58.59 48.2,58.56 48.09,58.56 48.03,58.56 48.03,58.56 46.76,58.56 46.65,58.44 v1(46.65,58.14)
  IN1 w0.127: v1(63.73,62.76) 63.91,62.93 63.91,63.17 63.69,63.39 60.63,63.39 59.35,62.11 58.84,62.11 58.39,61.66 57.52,61.66 56.89,61.03 54.25,61.03 54.15,60.93 51.16,60.93 49.43,59.2 49.43,59.22 49.01,58.79 48.46,58.79 48.27,58.6
  BOTTOM w0.089: v1(46.65,58.14) 46.24,57.73 45.19,57.73 45.12,57.66 44.32,57.66 44.2,57.78 43.87,57.78 43.56,57.47 43.05,57.47 42.98,57.51 42.91,57.54 42.84,57.57 42.79,57.57 42.53,57.45 42.34,57.45 U1.AW18
  BOTTOM w0.102: v1(63.73,62.76) 65.79,64.81 66.24,64.81 66.58,65.15 DIMM1.154
M_CHB_DQS5#: length 30.5
  IN1 w0.089: v1(46.04,58.13) 46.42,58.51 46.47,58.51 46.69,58.74 48.09,58.74 48.11,58.75
  IN1 w0.127: v1(64.41,62.76) 64.14,63.02 64.14,63.26 63.78,63.62 60.53,63.62 59.25,62.34 58.75,62.34 58.3,61.89 57.43,61.89 56.79,61.26 54.15,61.26 54.05,61.16 51.06,61.16 49.81,59.9 49.81,59.9 48.92,59.01 48.37,59.01 48.11,58.75
  BOTTOM w0.089: U1.AV18 41.87,57.62 42.49,57.62 42.57,57.67 42.75,57.75 42.88,57.75 43.02,57.68 43.1,57.65 43.49,57.65 43.79,57.95 44.27,57.95 44.39,57.83 45.04,57.83 45.12,57.91 45.81,57.91 46.04,58.13 v1(46.04,58.13)
  BOTTOM w0.102: DIMM1.152 66.33,64.55 66.27,64.61 65.87,64.61 64.41,63.14 v1(64.41,62.76)
M_CHB_DQS6: length 38.6
  IN1 w0.089: 46.75,62.92 46.73,62.91 46.71,62.91 45.7,61.9 45.7,61.71 44.15,60.16 43.85,60.16 43.26,59.57 43.26,58.82 41.05,56.61 41.05,55.44 40.69,55.08 38.98,55.08 v1(38.41,55.66)
  IN1 w0.127: v1(61.65,69.92) 61.16,69.44 60.7,69.44 60.52,69.26 59.92,69.26 58.8,68.14 58.19,68.14 57.89,68.44 57.89,68.95 58.7,69.76 58.7,69.92 58.43,70.2 58.19,70.2 57.11,69.13 57.11,68.6 56.65,68.14 55.12,68.14 54.74,68.52 53.54,68.52 51.79,66.77 49.81,66.77 47.47,64.42 47.47,63.64 46.75,62.92
  BOTTOM w0.102: DIMM1.171 60.76,70.25 60.84,70.34 61.23,70.34 v1(61.65,69.92) ; v1(38.41,55.66) 38.2,55.86 38.2,55.93 U1.AM21
M_CHB_DQS6#: length 38.7
  IN1 w0.089: 46.59,63.08 46.59,63.07 46.59,63.04 46.55,63.01 46.55,63.01 45.52,61.97 45.52,61.79 44.07,60.34 43.78,60.34 43.08,59.65 43.08,58.89 40.87,56.68 40.87,55.51 40.62,55.26 39.12,55.26 39.06,55.32 v1(39.06,55.66)
  IN1 w0.127: 46.59,63.08 47.25,63.73 47.25,64.51 49.73,67 51.69,67 53.44,68.75 54.83,68.75 55.21,68.37 56.56,68.37 56.89,68.7 56.89,69.22 58.09,70.43 58.52,70.43 58.93,70.02 58.93,69.66 58.12,68.85 58.12,68.54 58.29,68.37 58.71,68.37 59.83,69.49 60.43,69.49 60.53,69.59 60.53,70.2 60.61,70.27 60.96,70.27 61.01,70.22 v1(61.01,69.92)
  BOTTOM w0.089: v1(39.06,55.66) 39.06,55.99 38.99,56.05 U1.AN21
  BOTTOM w0.102: v1(61.01,69.92) 61.37,69.56 61.37,69.46 61.19,69.28 60.99,69.28 60.62,69.65 DIMM1.169
M_CHB_DQS7: length 39.9
  IN3 w0.089: v1(38.42,57.52) 38.66,57.28 38.66,57.14 38.87,56.93 41.88,56.93 43.45,58.51 43.45,59.52 44.77,60.83 44.77,61.83
  IN3 w0.114: 44.77,61.83 47.96,65.02 49.57,65.02 50.9,66.34 51.5,66.34 52.16,67 52.68,67 53.01,67.33 53.01,67.85 53.58,68.42 54.26,68.42 55.53,69.69 56.84,69.69 60.4,73.26 63.34,73.26 63.55,73.04 63.88,73.04 64.34,73.5 64.34,74.07 64.54,74.26 64.64,74.26 64.73,74.18 v1(64.97,74.18)
  BOTTOM w0.089: v1(38.42,57.52) 38.23,57.71 38.23,57.81 U1.AM18
  BOTTOM w0.102: DIMM1.188 66.6,75.35 66.45,75.2 66,75.2 v1(64.97,74.18)
M_CHB_DQS7#: length 40
  IN3 w0.089: v1(39.04,57.55) 38.84,57.35 38.84,57.22 38.95,57.11 41.8,57.11 43.28,58.58 43.28,59.59 44.58,60.89 44.58,61.93
  IN3 w0.114: v1(65.61,74.18) 65.18,74.6 64.77,74.6 64.65,74.49 64.44,74.49 64.11,74.16 64.11,73.59 63.79,73.27 63.65,73.27 63.43,73.49 60.31,73.49 56.74,69.92 55.43,69.92 54.16,68.65 53.48,68.65 52.78,67.95 52.78,67.42 52.59,67.23 52.06,67.23 51.41,66.57 50.8,66.57 50.67,66.43 50.67,66.4 49.49,65.22 47.87,65.22 44.58,61.93
  BOTTOM w0.089: v1(39.04,57.55) 38.86,57.73 38.86,57.82 U1.AN18
  BOTTOM w0.102: v1(65.61,74.18) 65.61,74.53 66.08,75 66.37,75 66.62,74.75 DIMM1.186
M_CHB_MAA0: length 30.8
  TOP w0.089: 46.41,45 46.32,45 46.03,44.71 45.81,44.71 44.98,43.88 44.98,43.88 44.93,43.83 44.42,43.83 43.94,43.35 43.61,43.35 43.6,43.35 41.31,43.35 41.03,43.07 39.92,43.07 v1(39.71,43.28)
  TOP w0.165: v1(65.57,47.91) 65.23,47.56 65.21,47.56 v2(64.82,47.17) 64.27,46.62 60.69,46.62 60.53,46.45 59.76,46.45 58.92,45.61 57.12,45.61 56.51,45 46.41,45
  BOTTOM w0.089: U1.AP40 39.52,43.53 39.52,43.47 v1(39.71,43.28)
  BOTTOM w0.165: DIMM1.98 66.45,48.35 66.45,48.36 66.02,48.36 v1(65.57,47.91)
M_CHB_MAA1: length 30.3
  TOP w0.089: 45.55,45.42 44.79,45.42 44.71,45.33 44.45,45.08 44.42,45.05 43.58,45.05 43.51,44.98 41.36,44.98 40.67,44.3 40.36,44.3 v1(40.21,44.15)
  TOP w0.165: v1(61.24,47.91) 60.21,47.91 60.01,47.71 59.24,47.71 58.48,46.95 57.32,46.95 56.94,47.33 56.43,47.33 55.83,46.73 55.48,46.73 55.37,46.63 55.37,46.4 55.23,46.26 54.57,46.26 54.46,46.37 54.46,46.58 54.28,46.75 54.06,46.75 53.93,46.62 53.59,46.62 v2(53.49,46.52) 53.24,46.27 52.71,46.27 52.38,46.6 51.83,46.6 51.49,46.26 50.12,46.26 49.77,46.6 49.07,46.6 48.74,46.27 48.31,46.27 48.08,46.5 48.08,47.44 47.96,47.57 47.42,47.57 47.3,47.44 47.3,46.65 47.12,46.47 46.31,46.47 46.15,46.32 46.15,46.02 45.56,45.42
  BOTTOM w0.089: v1(40.21,44.15) 40.03,43.97 U1.AR40
  BOTTOM w0.165: DIMM1.97 60.38,48.05 61.02,48.7 61.55,48.7 61.67,48.57 61.67,48.34 v1(61.24,47.91)
M_CHB_MAA2: length 33.5
  TOP w0.089: v1(39.06,43.28) 39.06,43.28 39.48,43.71 39.97,43.71 40.42,43.25 40.75,43.25 41.31,43.81 42.98,43.81 43.82,44.65 44.52,44.65 44.76,44.89 45.76,44.89 46.29,45.42 46.44,45.42
  TOP w0.165: v1(66.26,47.91) 66.76,47.91 66.88,48.02 66.88,48.28 66.55,48.61 v2(65.89,48.61) 65.48,48.61 63.91,47.04 60.52,47.04 60.36,46.87 59.59,46.87 58.75,46.03 56.95,46.03 56.33,45.42 46.44,45.42
  BOTTOM w0.089: v1(39.06,43.28) 39.22,43.12 39.22,43.02 U1.AP42
  BOTTOM w0.165: v1(66.26,47.91) 66.42,47.75 DIMM1.96
M_CHB_MAA3: length 32.3
  TOP w0.089: v1(40.59,43.65) 40.95,44.01 40.95,44.26 41.49,44.8 43.59,44.8 43.65,44.87 44.49,44.87 44.52,44.9 44.73,45.1 45.72,45.1 46.46,45.84
  TOP w0.165: v1(61.9,47.91) 62.16,48.18 62.16,48.34 62.38,48.56 62.82,48.56 63.1,48.28 63.1,48.28 63.16,48.22 63.91,48.22 64.06,48.07 64.06,47.78 63.74,47.46 60.35,47.46 60.18,47.29 59.41,47.29 58.57,46.45 56.5,46.45 v2(56.26,46.22) 55.88,45.84 46.46,45.84
  BOTTOM w0.089: v1(40.59,43.65) 40.59,43.12 40.33,42.86 U1.AR42
  BOTTOM w0.165: v1(61.9,47.91) 61.9,47.62 61.73,47.45 DIMM1.95
M_CHB_MAA4: length 38
  TOP w0.165: v1(40.35,41.51) 40.35,41.75 40.78,42.18 44.63,42.18 45.34,42.89 46.71,42.89 47.22,43.4 47.88,43.4 47.99,43.51 56.42,43.51 57.21,44.29 58.24,44.29 58.67,44.72 59.21,44.72 60.11,45.61 62.01,45.61 62.08,45.69 62.08,46.04 62.24,46.2 62.81,46.2 62.89,46.12 64.64,46.12 65.97,47.44 67.13,47.44 67.29,47.29 v2(67.29,47.03) 67.29,46.73 67.16,46.6 66.96,46.6 66.74,46.83 66.31,46.83 v1(65.65,46.17)
  BOTTOM w0.089: v1(40.35,41.51) 40.03,41.19 U1.AR45
  BOTTOM w0.165: v1(65.65,46.17) 65.31,46.17 65.03,46.45 65.03,47.16 65.23,47.36 66.24,47.36 66.45,47.16 66.45,46.73 66.63,46.55 DIMM1.92
M_CHB_MAA5: length 36.3
  TOP w0.165: v1(39.54,41.43) 39.73,41.43 39.9,41.6 39.9,41.88 39.52,42.26 39.52,42.64 39.68,42.79 40.5,42.79 40.7,42.59 40.85,42.59 41.4,43.13 43.52,43.13 43.52,43.13 44.03,43.13 44.24,43.35 44.61,43.35 44.79,43.17 45.1,43.17 45.2,43.27 45.2,43.79 45.37,43.96 45.59,43.96 45.87,43.68 45.87,43.43 46.1,43.2 46.56,43.2 46.81,43.45 46.81,43.65 v2(46.53,43.93) 46.23,44.24 46.23,44.49 46.36,44.62 47.02,44.62 47.12,44.52 47.12,44.01 47.32,43.81 47.87,43.81 47.99,43.93 48.18,43.93 48.29,44.04 48.29,44.47 48.39,44.57 48.95,44.57 49.1,44.42 49.1,44.06 49.23,43.93 49.63,43.93 49.77,44.07 49.77,44.4 49.94,44.57 50.27,44.57 50.43,44.4 50.43,44.09 50.6,43.93 50.93,43.93 51.09,44.09 51.09,44.4 51.26,44.57 51.59,44.57 51.75,44.4 51.75,44.09 51.92,43.93 52.25,43.93 52.41,44.09 52.41,44.4 52.58,44.57 52.91,44.57 53.07,44.4 53.07,44.09 53.24,43.93 53.57,43.93 53.73,44.09 53.73,44.4 53.9,44.57 54.23,44.57 54.39,44.4 54.39,44.09 54.56,43.93 54.89,43.93 55.06,44.09 55.06,44.4 55.22,44.57 55.55,44.57 55.72,44.4 55.72,44.09 55.88,43.93 56.25,43.93 56.42,44.1 56.42,44.45 56.56,44.58 56.68,44.58 57.29,45.2 57.67,45.2 57.99,44.87 58.23,44.87 58.49,45.14 59.04,45.14 59.93,46.03 60.78,46.03 v1(60.92,46.17)
  BOTTOM w0.089: U1.AP45 39.38,41.26 v1(39.54,41.43)
  BOTTOM w0.165: v1(60.92,46.17) 60.83,46.25 DIMM1.91
M_CHB_MAA6: length 40.6
  TOP w0.165: v1(66.3,46.17) 66.45,46.32 66.65,46.32 66.85,46.12 66.85,45.86 66.44,45.45 66.13,45.45 65.89,45.7 62.96,45.7 62.87,45.61 62.87,45.33 62.73,45.2 60.28,45.2 59.39,44.3 58.84,44.3 58.41,43.87 57.38,43.87 56.6,43.09 47.31,43.09 46.74,42.51 45.59,42.51 44.81,41.72 44.48,41.72 44.3,41.9 43.84,41.9 43.54,41.6 43.13,41.6 42.83,41.9 42.39,41.9 42.01,41.52 41.71,41.52 41.33,41.9 41.02,41.9 40.79,41.67 40.79,41.33 40.52,41.06 39.83,41.06 39.68,40.91 39.68,40.58 39.81,40.45 v2(40.01,40.45) 40.34,40.45 40.41,40.51 40.95,40.51 41.03,40.43 41.03,40.12 41.17,39.97 41.84,39.97 41.99,40.12 41.99,40.43 42.17,40.61 43.59,40.61 43.71,40.48 43.71,40.07 43.59,39.95 42.9,39.95 42.83,39.87 v1(42.83,39.5)
  BOTTOM w0.089: v1(42.83,39.5) 42.83,39.57 U1.AW46
  BOTTOM w0.165: DIMM1.90 66.51,45.95 v1(66.3,46.17)
