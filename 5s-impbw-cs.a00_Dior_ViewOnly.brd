# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+EXT_DC_IN: length 253.5
  TOP w0.381: v1(163.4,66.79) 163.57,66.96 PD8.3 ; v1(147.3,30.32) 147.3,37.65 147.59,37.94 PR79.1 148.17,40.17 PR73.1 148.17,42.42 148.54,42.79 v1(148.54,44.26) 147.91,44.26 146.2,45.97 144.93,45.97 144.22,46.68 144.22,49.38 v1(143.85,49.75) ; 7.8,57.73 5.72,57.73 4.75,56.76 4.75,48.94 2.87,47.06 2.87,36.29 4.36,34.8 4.36,32.47 4.14,32.25 4.14,29.98 6.77,27.35 16.51,27.35 18.3,25.56 v1(18.3,23.99)
  IN1 w0.381: v1(147.3,30.32) 143.89,30.32 136.45,22.88 128.65,22.88 127.53,21.76 121.71,21.76 120.79,22.67 105.19,22.67 102.02,19.5 101.57,19.5 98.98,16.91 96.95,16.91 94.87,18.99 90.89,18.99 88.88,16.97 88.88,16.88 87.56,15.56 87.15,15.56 84.56,12.97 78.41,12.97 78.08,12.64 66.93,12.64 66.6,12.31 62.16,12.31 61.49,12.97 53.04,12.97 51.84,14.17 47.12,14.17 42.52,18.76 39.35,18.76 37.9,20.21 30.5,20.21 29.48,21.23 21.42,21.23 18.7,23.94 18.35,23.94 v1(18.3,23.99) ; v1(163.4,66.79) 163.39,66.79 162.71,66.11 161.77,66.11 159.01,63.34 155.29,63.34 147.61,55.66 145.03,55.66 142.56,53.18 142.56,50.76 143.56,49.75 v1(143.85,49.75)
  BOTTOM w0.381: PD3.2 146.17,40.83 147.58,42.23 147.58,43.3 v1(148.54,44.26)
  vias: v2(9.91,60.29)
+PCH_VCCDSW: length 2
  TOP w0.457: PR43.2 35.23,57.31 v1(35.67,56.87)
  BOTTOM w0.305: U1.AG20 35.3,56.5 v1(35.67,56.87) 35.67,56.9 U1.AG19
+PCH_VCCDSW_R: length 2.5
  TOP w0.508: PC26.1 35.52,56.23 35.44,56.23 35.37,56.3 35.07,56.3 PR43.1 34.03,56.42 v2(33.84,56.22)
+RTC_BAT: length 2.5
  BOTTOM w0.381: v2(169.8,78.63) 169.55,78.88 R69.2 169.08,79.61 D1.2
+RTCBAT: length 16.4
  IN2 w0.381: v1(172.54,80.95) v1(172.54,78.17)
  BOTTOM w0.381: v1(172.54,78.17) 172.54,77.3 T9208.1 ; v1(172.54,80.95) 169.99,80.95 169.55,80.51 R69.1 168,81.99 CON1.2
+V_VREF_CA_DIMM: length 135.4
  TOP w0.254: U2.M8 81.15,27.45 81.15,27.45 v1(81.18,27.42) ; v1(81.18,59.55) 80.79,59.15 U4.M8 ; U3.M8 81.19,39.75 v1(81.18,39.75) ; U5.M8 81.18,71.09 v1(81.18,71.09)
  TOP w0.508: v1(50.93,15.97) 50.93,16.69 51.07,16.83 R41.1 50.37,17.49 50.27,17.6 R43.1 R45.2 C1189.1 C1191.1 46.48,18.28 47.44,19.23 C1190.1 47.44,20.83 v1(48.21,21.61) ; C1188.1 74.11,18.86 v1(74.4,18.58)
  IN1 w0.508: v1(48.21,21.61) 48.69,21.12 55.32,21.12 57.72,18.73 62.99,18.73 63.38,18.34 67.03,18.34 67.6,18.91 70.92,18.91 71.43,19.42 73.55,19.42 v1(74.4,18.58)
  IN2 w0.305: v1(89.05,60.19) 88.93,60.32 84.53,60.32 83.76,59.55 v1(81.18,59.55) ; v1(88.48,39.77) 87.07,38.35 82.63,38.35 81.23,39.75 v1(81.18,39.75)
  IN3 w0.305: v1(88.48,39.77) 87.66,38.94 87.66,35.04 88.63,34.07 88.63,32.12 86.91,30.4 85.6,30.4 82.62,27.42 v1(81.18,27.42) ; v1(89.05,60.19) 90.17,61.31 90.17,67.61 89.9,67.87 88.31,67.87 87.49,68.7 86.06,68.7 85.12,69.64 82.64,69.64 v1(81.18,71.09)
  IN3 w0.508: v1(88.48,39.77) 88.48,41.93 88.67,42.12 88.67,48.2 90.09,49.62 90.09,52.47 88.16,54.4 88.16,59.3 v1(89.05,60.19)
  BOTTOM w0.508: v1(50.93,15.97) 50.93,15.71 v2(51.33,15.31) ; v1(74.4,18.58) 76.42,18.58 77.71,19.87 81.75,19.87 83.23,21.35 83.23,21.86 82.05,23.04 82.05,25.15 81.68,25.51 81.68,26.92 v1(81.18,27.42)
+V_VREF_DQ_DIMM0: length 92.2
  TOP w0.305: v1(77.99,22.61) 77.59,22.21 U2.H1 77.76,22.03 77.76,21.19 ; U5.H1 77.58,64.68 76.8,63.9 v1(76.58,63.9) ; v1(76.05,32.07) 76.43,32.45 77,32.45 77.58,33.04 U3.H1 ; 76.56,52.29 76.84,52.57 77.32,52.57 77.62,52.87 77.62,53.31 77.58,53.35 U4.H1
  TOP w0.508: 76.56,52.29 v1(76.47,52.21) 75.49,51.22 75.4,51.22 74.92,50.74 C1187.1 ; v1(70.14,39.16) 69.93,38.94 C1186.1 ; 77.76,21.19 76.6,20.02 C1184.1 76.6,18.43 76.77,18.25 R42.2 77.32,17.75 77.75,18.18 77.75,18.8 R44.2 77.81,19.23 78.26,19.68 80.8,19.68 81.14,19.33 C1185.1 R40.1
  IN1 w0.508: v1(70.14,39.16) 70.16,39.15 73.19,39.15 73.86,39.82 75.71,39.82 76.48,40.59 76.48,41.79 78.03,43.34 78.03,49.37 76.47,50.93 v1(76.47,52.21) 74.6,54.08 74.6,57.52 73.55,58.58 73.55,60.23 73.94,60.62 73.94,61.08 76.58,63.72 v1(76.58,63.9)
  BOTTOM w0.305: v1(77.99,22.61) 77.42,23.18 77.42,23.59 77.9,24.07 77.9,25.24 77.5,25.64 77.5,26.16 77.71,26.37 77.71,26.94 76.66,27.99 76.66,28.42 76.82,28.59 76.82,30.95 76.05,31.72 v1(76.05,32.07)
  BOTTOM w0.508: v1(77.99,22.61) 78.41,22.19 78.41,21.43 78.06,21.07 77,21.07 75.74,22.33 v2(75.74,23.11) 75.74,23.98 73.74,25.99 73.73,25.99 71.73,27.99 71.73,30.57 70.41,31.89 70.41,34.31 70.14,34.57 v1(70.14,39.16)
+VCORE: length 1.2
  TOP w0.127: 18.65,37.74 19.25,37.74
  BOTTOM w0.254: v1(24.35,32.25) 24.33,32.25 24.28,32.2 24.28,32.07 U1.F59
  vias: v1(4.9,44.52) v1(5.54,44.52) v1(6.17,44.52) v1(6.92,44.54) v1(7.59,44.54) v1(8.3,44.54) v1(12.14,40.76) v1(12.13,40.07) v1(12.22,42.69) v1(12.22,42.03) v1(13.57,40.91) v1(13.57,40.23) v1(23.07,46.26) v1(23.06,43.72) v1(23.06,41.23) v1(23.07,33.69) v1(23.1,53.64) v1(23.09,51.4) v1(23.1,48.69) v1(23.09,38.66) v1(23.09,36.11) v1(24.2,53.65) v1(24.18,51.18) v1(24.21,48.77) v1(24.26,46.23) v1(24.21,43.77) v1(24.19,41.23) v1(24.26,38.76) v1(24.19,36.23) v1(24.56,33.33) v1(25.25,35.08) v1(25.32,53.37) v1(25.32,52.73) v1(25.32,51.13) v1(25.32,50.47) v1(25.32,48.82) v1(25.32,46.56) v1(25.32,45.85) v1(25.32,44.53) v1(25.32,43.87) v1(25.3,42.13) v1(25.32,41.48) v1(25.32,39.98) v1(25.32,39.32) v1(25.32,37.95) v1(25.3,37.32) v1(25.3,35.74) v1(26.65,33.75) v1(26.72,54.28) v1(29.24,33.65) v1(30.53,33.63) v1(31.83,33.65) v2(21.92,45.36) v3(6.1,40.35) v3(6.35,41.24) v3(6.96,39.92) v3(7.16,43.55) v3(7.16,42.63) v3(7.19,41.72) v3(7.19,40.81) v3(7.93,39.92) v3(8.05,43.58) v3(8.05,42.64) v3(8.15,40.81) v3(8.18,41.72)
+VCORE_ALERT#_A: length 7.1
  BOTTOM w0.203: PU4.32 12.63,16.33 12.16,15.86
  BOTTOM w0.254: v2(11,11.07) 11.58,11.65 11.83,11.65 PR98.2 11.51,12.61 11.51,14.27 11.71,14.47 PR105.1 12.16,15.86
+VCORE_BST1_R1_RC_D:
  vias: v2(4.09,27.12)
+VCORE_COMP_A: length 8.8
  TOP w0.254: v1(16.31,15.31) 16.31,14.96 PC81.1 16.79,13.93 16.78,13.92 PR114.1 16.78,13.09 16.7,13 PC82.1 16.33,12.03 16.02,11.73 16.02,11.1 15.82,10.9 PR115.1
  BOTTOM w0.203: PU4.26 15.03,16.28 15.2,16.11
  BOTTOM w0.254: 15.2,16.11 15.2,15.73 15.67,15.26 v2(15.67,14.83) 16.03,14.83 16.31,15.1 v1(16.31,15.31)
+VCORE_CSN1: length 43.4
  TOP w0.203: v1(7.08,24.51) 7.23,24.66 7.55,24.66 11.89,20.31 13.87,20.31 v2(14.15,20.03) 14.43,20.31 16.11,20.31 16.41,20.01 16.71,20.01 17.43,19.29 v1(17.77,19.29) 17.78,19.28 17.78,18.99 18.37,18.41 PC79.1 18.47,18.41 PC80.1 19.52,18.4 PR113.2
  IN1 w0.203: v1(7.08,24.51) 7.18,24.51 8.42,25.75 10.29,25.75 11.63,27.09 11.63,34.02 10.89,34.77 10.89,36.28 10.09,37.08 9.42,37.08 8.94,37.56 v1(8.94,37.89)
  BOTTOM w0.152: 4.86,41.04 PJP10.1
  BOTTOM w0.203: 4.86,41.04 4.86,39.91 5.41,39.36 6.15,39.36 6.33,39.18 7.34,39.18 8,38.53 PRT4.2 9.02,37.96 v1(8.94,37.89) ; PU4.18 16.31,19.49 16.39,19.58 16.9,19.58 17.19,19.29 v1(17.77,19.29)
+VCORE_CSP1: length 8
  BOTTOM w0.152: 4.99,38.75 PJP9.1
  BOTTOM w0.203: 4.99,38.75 4.99,38.84 5.16,39.01 6,39.01 6.17,38.83 7.19,38.83 9.03,36.99 PR111.2 9.03,36.48 10.19,35.32 v2(10.57,35.32)
+VCORE_CSP1_A: length 35.9
  TOP w0.203: PR113.1 19.52,19.29 PC80.2 18.47,19.3 PC79.2 18.47,19.65 18.23,19.89 17.59,19.89 v1(17.58,19.9) 17.35,19.9 v2(16.69,20.57) 16.59,20.67 12.04,20.67 7.69,25.01 7.24,25.01 v1(7.11,25.14)
  IN1 w0.203: v1(7.11,25.14) 7.38,25.14 8.29,26.05 10.14,26.05 11.3,27.22 11.3,33.92 10.58,34.65 10.58,36.15 10.14,36.59 v1(9.86,36.59)
  BOTTOM w0.203: v1(17.58,19.9) 17.57,19.89 PU4.17 ; v1(9.86,36.59) 10.06,36.8 PR111.1 10.83,37.58 10.47,37.95 PR112.1
+VCORE_CSP1_NTC_A: length 1.5
  BOTTOM w0.203: PR112.2 PRT4.1
+VCORE_CSP2_A: length 2.9
  BOTTOM w0.203: PU4.20 16.33,18.69 16.49,18.53 16.54,18.53 v2(17.1,17.98) 17.65,18.53 PR117.2
+VCORE_DROOP_A: length 7.9
  TOP w0.254: PR116.2 17.76,12.82 17.67,12.9 PR114.2 18.43,13.39 18.77,13.73 v2(18.77,14.17) 18.46,14.48 PC81.2 17.68,15.06 v1(17.45,15.28)
  BOTTOM w0.203: 15.72,16.12 15.43,16.41 PU4.25
  BOTTOM w0.254: v1(17.45,15.28) 16.87,15.87 15.98,15.87 15.72,16.12
+VCORE_EN_A: length 8.9
  BOTTOM w0.102: PU4.8 11.01,19.89 PC78.1 9.67,21.23 8.54,21.23 PR107.2 PR102.2 8.07,22.25 7.77,22.55 PR217.2
  BOTTOM w0.127: PR217.2 6.58,23.03 v2(6.25,22.7)
+VCORE_F-IMAX_A: length 8.6
  BOTTOM w0.203: PU4.10 13.03,20.83 12.73,21.13
  BOTTOM w0.254: 12.73,21.13 12.63,21.23 11.53,21.23 10.51,22.25 10.4,22.25 9.99,22.66 PR123.2 10.41,22.99 10.58,23.16 10.58,24.92 v2(10.44,25.06) 11.04,25.66 PR124.2
+VCORE_FB+_A: length 33.9
  TOP w0.152: v1(9.83,38.33) 9.97,38.19 10.25,38.19 10.51,38.45 PJP6.1
  TOP w0.254: v1(20.52,14.98) 20.78,14.72 v2(21.39,14.72)
  IN3 w0.203: v1(20.52,14.98) 19.05,14.98 15.88,18.15 15.14,18.15 10.31,22.98 10.31,25.82 11.33,26.84 11.33,31.36 9.32,33.37 9.32,34.87 9.02,35.17 9.02,36.97 9.45,37.41 9.45,37.95 v1(9.83,38.33)
  BOTTOM w0.254: v1(20.52,14.98) 20.52,14.98 PR128.1
+VCORE_FB-_A: length 30.6
  TOP w0.152: PJP7.1 10.54,37.81 10.44,37.91 10.01,37.91 9.92,37.83 v1(9.92,37.61)
  TOP w0.254: v1(19.84,17.33) 19.82,17.31 v2(19.05,17.31)
  IN3 w0.203: v1(19.84,17.33) 19.84,17.34 19.64,17.14 17.4,17.14 16.03,18.51 15.3,18.51 10.67,23.14 10.67,25.68 11.63,26.64 11.63,31.48 9.67,33.44 9.67,35.02 9.37,35.32 9.37,36.82 9.92,37.37 v1(9.92,37.61)
  BOTTOM w0.254: PR133.1 v1(19.84,17.33)
+VCORE_GFB_A: length 6.6
  BOTTOM w0.203: PU4.23 16.69,17.49
  BOTTOM w0.254: PR133.2 16.85,17.33 16.69,17.49 ; PR133.2 18.19,17.32 18.19,16.73 18.39,16.53 PR131.2 ; PR133.2 18.2,17.6 18.49,17.89 19.96,17.89 v2(20.5,18.43)
+VCORE_IMON1_A: length 2.9
  TOP w0.254: v2(11.84,23.59) 12.14,23.89 v1(12.98,23.89)
  BOTTOM w0.254: PR224.1 13.28,23.59 v1(12.98,23.89) 12.94,23.85 PR127.2
+VCORE_IMON_A: length 6.3
  TOP w0.254: v1(12.98,24.57) 13.42,24.57 14.02,23.97 v2(14.02,23.41) 13.69,23.08 PC85.1 13.69,21.64 14.01,21.32 v1(14.33,21.32)
  BOTTOM w0.203: PU4.13 14.23,21.22 v1(14.33,21.32)
  BOTTOM w0.254: PR127.1 12.81,24.74 v1(12.98,24.57)
+VCORE_IN:
  vias: v2(5.26,24.4)
+VCORE_IN_A: length 12.7
  TOP w0.254: v1(7.1,25.78) 7.86,26.53 v2(9.55,26.53) 14.89,26.53 v1(16.79,24.63)
  BOTTOM w0.152: PJP8.1 6.94,25.94 v1(7.1,25.78)
  BOTTOM w0.254: v1(16.79,24.63) 17.02,24.4 PR106.1
+VCORE_MODE_A: length 4.1
  TOP w0.508: v1(11.41,18.51) 11.41,19.02 v2(11.79,19.4)
  BOTTOM w0.203: v1(11.41,18.51) 11.62,18.29 PU4.4
  BOTTOM w0.254: v1(11.41,18.51) 11.13,18.23 10.59,18.23 10.16,18.66 10.16,18.77 PR132.1
+VCORE_O-USR_A: length 10.2
  BOTTOM w0.203: PU4.9 12.63,20.63 12.42,20.84
  BOTTOM w0.254: 12.42,20.84 12.27,20.84 11.84,20.41 11.08,20.41 10.77,20.72 10.77,21.25 10.21,21.81 v2(9.45,21.81) 8.83,22.43 PR125.2 9.26,22.99 9.42,23.16 9.42,24.3 9.25,24.48 9.25,25.6 PR126.1
+VCORE_OCP-I_A: length 7.8
  TOP w0.254: v1(13.02,25.35) 12.9,25.47 v2(12.22,25.47)
  BOTTOM w0.203: 13.83,21.39 PU4.12
  BOTTOM w0.254: PR129.1 13.1,25.44 v1(13.02,25.35) 13.49,24.88 13.49,24.05 13.84,23.69 13.84,22.5 13.55,22.2 PR224.2 13.83,21.65 13.83,21.39
+VCORE_PWM1: length 16.5
  TOP w0.254: v1(2.48,27.92) 2.48,26.12 7.16,21.44 7.54,21.44 v2(8.41,20.57) 9.36,20.57 10.11,19.81 10.11,19.42 v1(10.72,18.81)
  BOTTOM w0.203: v1(10.72,18.81) 11,18.81 11.28,19.09 PU4.6 ; PU5.8 3.34,29.01 2.48,28.15 v1(2.48,27.92)
+VCORE_SCLK_A: length 7.2
  BOTTOM w0.203: 12.85,15.54 12.85,15.82 13.03,15.99 PU4.31
  BOTTOM w0.254: v2(14.4,11.04) 13.47,11.97 PR99.2 12.8,12.41 12.8,13.94 13.19,14.32 PR104.1 12.85,14.93 12.85,15.54
+VCORE_SDA_A: length 4.9
  BOTTOM w0.203: PU4.1 11.63,17.09 11.32,16.78
  BOTTOM w0.254: 11.32,16.78 11.23,16.69 11.23,16.04 v2(11.58,15.69) 10.92,15.02 PR100.2 10.2,14.48 PR101.1
+VCORE_SKIP#: length 22.3
  TOP w0.381: v1(2.6,29.23) 3.73,29.23 4.12,28.85 4.12,25.52 7.49,22.14 7.8,22.14 8.69,21.25 10.06,21.25 v2(10.09,21.23) 10.85,20.47 v1(10.85,19.49)
  BOTTOM w0.203: PR134.2 3.39,32.91 PU5.1 ; v1(10.85,19.49) PU4.7
  BOTTOM w0.381: v1(2.6,29.23) 1.86,29.97 1.86,32.44 PR134.2
+VCORE_SLEWA_A: length 8.5
  TOP w0.254: v2(17.1,25.72) 17.38,25.44 v1(17.38,24.96)
  BOTTOM w0.203: PU4.15 15.03,20.83 15.25,21.04
  BOTTOM w0.254: v1(17.38,24.96) 17.38,25.37 17.06,25.69 PR119.1 16.54,25.21 16.3,24.96 16.3,24.36 16.39,24.27 16.39,22.88 16.19,22.68 PR118.2 15.83,21.63 15.25,21.04
+VCORE_SN1_C: length 1
  TOP w0.254: v1(8.15,33.02) 8.15,32.3 v2(8.33,32.12)
+VCORE_SW1_R: length 0.8
  TOP w0.508: v1(6.73,34.87) v2(6.73,34.05)
+VCORE_THERM_A: length 18.9
  BOTTOM w0.203: 14.84,21.14 14.63,20.93 PU4.14
  BOTTOM w0.254: PRT5.2 9.46,30.03 11.02,28.47 13.34,28.47 13.69,28.11 14.56,28.11 14.73,27.93 14.73,26.74 14.59,26.6 PR120.1 14.17,25.16 13.84,24.83 13.84,24.3 14.2,23.94 14.2,23.33 14.35,23.18 14.54,23.18 PC84.1 14.79,21.87 v2(14.8,21.86) 14.84,21.82 14.84,21.14
+VCORE_V5A_C: length 7.4
  TOP w0.508: v1(14.2,15.23) 14.2,14.73 PC76.1 12.36,14.29 v2(12.19,14.11) 12.93,13.38 12.93,12.26 13.3,11.89 PR103.2
  BOTTOM w0.203: v1(14.2,15.23) 14.38,15.41 14.38,16.01 14.23,16.15 PU4.28
+VCORE_VBAT_A: length 5.7
  BOTTOM w0.203: v2(17.12,20.6) 16.8,20.29 16.44,20.29 15.9,20.82 15.59,20.82 15.43,20.66 PU4.16
  BOTTOM w0.254: v2(17.12,20.6) 16.78,20.6 16.23,21.15 16.23,21.84 17.02,22.62 PR106.2
+VCORE_VDD_C: length 7.3
  BOTTOM w0.203: 11.06,17.32 11.43,17.32 11.6,17.49 PU4.2
  BOTTOM w0.508: 11.06,17.32 10.89,17.32 PC75.1 10.22,15.85 9.65,15.28 v2(9.04,15.28) 9.03,15.27 7.96,15.27 7.29,15.95 PR97.2
+VCORE_VFB_A9: length 6.1
  BOTTOM w0.203: 16.99,16.63 16.53,17.09 PU4.24
  BOTTOM w0.254: 16.99,16.63 17.48,16.15 17.48,16.02 18.4,15.09 PR128.2 18.2,14.77 PR130.2 17.5,13.78 v2(17.02,13.3)
+VCORE_VREF_A: length 44.2
  TOP w0.254: v1(15.58,24.62) v2(14.7,25.49) 14.15,26.04 11.83,26.04 11.18,25.39 v1(11.18,25.04) 9.93,25.04 9.76,25.21 v1(9.74,25.21) v1(8.74,25.21) ; PR115.2 15.45,11.79 16.13,12.46 16.13,13.53 15.42,14.24 PC83.1 15.42,14.65 v1(14.96,15.11)
  IN2 w0.254: v1(14.96,15.11) 15.8,15.94 15.8,24.39 v1(15.58,24.62)
  BOTTOM w0.203: v1(14.96,15.11) 14.82,15.25 14.82,16.05 14.63,16.23 PU4.27
  BOTTOM w0.254: PR125.1 8.83,24.57 8.74,24.66 v1(8.74,25.21) ; v1(11.18,25.04) 11.14,25 PR121.1 ; PRT5.1 9.87,34.88 10.09,34.66 10.09,33.59 9.86,33.36 9.86,30.24 11.28,28.82 13.51,28.82 13.84,28.49 14.71,28.49 15.09,28.11 15.09,25.1 v1(15.58,24.62) 15.83,24.36 PR118.1 ; v1(9.74,25.21) 9.76,25.2 9.76,24.68 9.99,24.44 PR123.1
+VCOREB_RAMP_A: length 7.9
  BOTTOM w0.203: PU4.11 13.43,20.98
  BOTTOM w0.254: PR122.1 11.71,25.97 11.71,23.16 11.53,22.97 PR121.2 11.14,22.63 11.48,22.29 12.03,22.29 v2(12.17,22.15) 12.62,21.7 12.72,21.7 13.43,20.98
+VTT_DDR: length 95.3
  TOP w0.305: 79.69,48.09 R19.2 79.52,48.87 79.26,49.13 R26.2 77.75,49.13 R4.2
  TOP w0.457: PR176.1 115.05,60.24 PC157.1 PC158.1
  TOP w0.508: 86.97,42.11 R18.2 ; R18.2 87.57,42.7 ; R18.2 86.37,42.7 ; C24.1 89.33,41.9 ; C24.1 89.93,41.3 ; C24.1 88.74,41.3 ; 86.08,41.29 C22.1 86.67,41.89 ; 71.46,47.55 C28.1 70.87,48.15 ; 86.2,53.7 C25.1 86.79,53.1 ; 80.23,47.83 R7.2 80.82,47.24 ; 89.79,48.33 R15.2 ; 71.94,48.37 R28.2 72.54,48.97 ; 89.19,52.1 R11.2 89.79,51.5 ; v3(112.85,59.86) 113.01,59.71 PC158.1 ; 89.79,50.46 R10.2 ; 81.87,47.24 R8.2 82.46,47.83 ; 83.61,46.18 R3.2 84.2,46.78 ; 88.31,41.29 D3CE37.1 87.71,41.89 ; 89.79,45.03 R16.2 ; 84.16,50.83 R6.2 84.76,50.23 ; 89.57,52.49 C27.1 90.17,51.89 ; 89.79,46.12 R17.2 ; R20.2 85.45,42.99 85.5,42.94 ; D3CE39.1 59.97,81.59 C23.1 60.42,81.61 60.56,81.47 D3CE40.1 61.2,81.46 61.2,81.03 D3CE41.1 ; 73.48,49.17 R1.2 ; 88.72,42.11 R23.2 ; 88.94,53.09 D3CE36.1 ; 76.76,46.42 R2.2 ; 89.79,49.39 R22.2 ; R25.2 77.74,45.13 ; D3CE41.1 61.19,80.09 v1(61.04,79.94) ; D3CE41.1 61.93,80.61 62.47,80.06 66.98,80.06 67.69,80.78 D3CE38.1 68.68,80.26 v1(69.09,79.85) ; 72.85,44.59 R21.2 73.45,45.19 ; 89.79,47.26 R13.2 ; 70.85,48.37 R27.2 ; 77.83,46.42 R14.2 ; 75.67,46.42 R9.2 ; 73.28,46.52 R12.2 ; 72.85,43.5 R24.2 ; R5.2 78.82,45.13 ; 91.23,51.9 C26.1 ; 87.87,53.09 C29.1
  IN3 w0.762: v3(89.28,67.1) 89.03,67.1 88.7,66.77 88.7,60.93 87.33,59.55 87.33,54.09 v3(88.85,52.57)
  BOTTOM w0.356: DIMM1.204 68.79,80.15 v1(69.09,79.85) ; v1(61.04,79.94) 60.95,79.85 DIMM1.203
  BOTTOM w0.635: v3(89.28,67.1) 88.95,67.1 87.81,68.24 87.81,72.38 86.29,73.91 75.77,73.91 71.38,78.3 v3(71.38,79.95)
  vias: v1(91.04,50.06) v1(91.01,49.37) v2(71.07,80.76)
+VTT_DDR_VTTSNS_A: length 36.7
  TOP w0.127: v2(115.85,61.94) 115.85,61.23 115.55,60.93 115.18,60.93 115.12,60.98 114.13,60.98 113.91,60.76 PR176.2 ; v1(91.99,51.2) 91.82,51.36 PR234.1
  TOP w0.203: PU7.2 113.15,61.41 v1(113.21,61.36) 113.46,61.1 113.46,60.99 PR176.2
  IN2 w0.254: v1(113.21,61.36) 114.68,59.89 114.68,58.74 114.45,58.51 113.87,58.51 113.21,57.86 111.61,57.86 107.39,53.64 107.39,51.87 106.72,51.2 v1(91.99,51.2)
+VTTREF_A: length 2.6
  TOP w0.203: PC159.1 113.49,61.84 v2(113.49,62.45) 112.78,62.45 112.54,62.21 PU7.4
A20GATE: length 5.8
  TOP w0.102: v1(101.35,72.34) 101.35,72.25 101.81,71.8 102.44,71.8 v2(102.74,72.1) 103.12,72.1 103.76,72.75 103.76,73.46 SR29.2
  BOTTOM w0.102: v1(101.35,72.34) 101.35,73.15 101.38,73.18 U10.126
A_DE: length 8.4
  TOP w0.102: U21.9 178.76,51.9 179.14,51.53 179.91,51.53 R389.1 180.72,51.48 182.13,51.48 R387.2 183,51.53 183.5,51.53 183.9,51.93 v2(185.88,51.93)
A_EQ1: length 4.9
  TOP w0.102: R381.2 171.12,52.35 v2(171.67,52.35) 173.03,52.35 R385.1 173.98,51.4 U21.18
A_EQ2: length 4.8
  TOP w0.102: R380.2 171.25,50.32 v2(171.67,50.32) 172.9,50.32 R384.1 174.19,50.89 174.21,50.9 U21.19
AC_IN_OC: length 2
  TOP w0.102: T61.1 137.01,46.39 v1(137.01,46.3)
  BOTTOM w0.102: PR90.2 137.01,46.4 v1(137.01,46.3)
AC_IN_OC#: length 71.6
  TOP w0.102: v1(125.45,68.17) 124.84,67.56 120.57,67.56 119.58,68.54 119.58,68.65 T60.1 118.84,69.39 v1(118.62,69.39) ; v1(139.85,42.03) 138.9,42.03 138.7,41.82 138.7,40.12 138.85,39.97 PQ10.6 ; v1(104.33,75.22) 104.35,75.22 104.61,75.48 R174.2
  IN1 w0.102: v1(104.33,75.22) 104.74,75.64 107.94,75.64 108.78,74.8 109.58,74.8 114.98,69.39 v1(118.62,69.39)
  IN3 w0.102: v1(125.45,68.17) 126.01,68.72 126.49,68.72 127.56,67.66 128.54,67.66 128.93,67.27 128.93,65.01 128.36,64.45 128.36,60.99 129.02,60.33 129.02,59.63 130.57,58.08 133.78,58.08 135.69,56.18 136.47,56.18 137.89,54.76 137.89,53.98 137.38,53.47 137.38,52.72 138.41,51.69 138.41,49.83 139.32,48.91 139.32,48.4 140.49,47.24 141,47.24 142.2,46.03 142.2,44.81 141.05,43.65 141.05,42.03 140.67,41.65 140.23,41.65 v1(139.85,42.03)
  BOTTOM w0.102: U10.120 103.78,74.92 104.09,75.22 v1(104.33,75.22)
AC_IN_OC_EC: length 114.4
  TOP w0.089: 36.99,70.68 PR31.1
  TOP w0.102: v1(84.57,85.3) 84.57,87.28 83.13,88.72 70.47,88.72 70.04,88.29 63.69,88.29 63.26,87.86 58.23,87.86 55.23,84.87 48.18,84.87 46.13,82.81 46.13,82.59 43.49,79.95 43.22,79.95 42.8,79.53 42.8,78.38 42.23,77.81 40.61,77.81 38.85,76.06 38.85,73.22 38.62,72.99 37.98,72.99 PR29.2 37.49,71.77 36.99,71.27 36.99,70.68 ; v1(111.32,69.97) 111.32,72.27 112.14,73.09 v1(112.14,75.61) ; v2(92.43,69.36) 92.38,69.36 v1(91.31,70.43)
  IN2 w0.102: v1(91.31,70.43) 91.92,69.82 94.17,69.82 96.41,72.06 99.23,72.06 100.46,73.28 106.97,73.28 110.29,69.97 v1(111.32,69.97)
  BOTTOM w0.102: v1(84.57,85.3) 84.35,85.08 84.35,83.22 82.56,81.43 82.56,78.07 84.25,76.38 87.06,76.38 88.07,75.36 88.07,74.4 89.45,73.02 89.45,72.45 91.31,70.58 v1(91.31,70.43) ; U10.98 112.58,74.94 112.14,75.38 v1(112.14,75.61)
AC_PRESENT_R: length 8.9
  TOP w0.089: PR31.2 36.99,68.98 36.76,68.75 36.76,68.53 35.16,66.92 35.16,63.36 35.61,62.91 v1(35.61,62.67)
  BOTTOM w0.089: U1.AJ8 36.23,63.07 36.07,63.07 35.66,62.67 v1(35.61,62.67)
ACC_INT1_IO: length 39.3
  TOP w0.102: v1(160.19,73.73) 159.18,74.74 v2(159.18,75.05) 159.49,75.35 159.49,77.95 157.25,80.18 157.25,84.47 158.37,85.59 159.69,85.59 159.9,85.38 159.9,84.83 159.59,84.52 U17.11
  IN1 w0.127: v1(179.1,77.33) 177.9,76.14 172.28,76.14 171.72,75.58 169.09,75.58 168.17,74.67 162.74,74.67 161.81,73.73 v1(160.19,73.73)
  BOTTOM w0.102: R359.2 179.11,77.35 v1(179.1,77.33) ; U20.28 160.27,73.81 v1(160.19,73.73)
ACC_INT1_IO_R: length 11.1
  TOP w0.102: v1(179.78,77.56) 179.59,77.75 178.92,77.75 178.39,77.22 v2(178.39,76.93)
  BOTTOM w0.102: v1(179.78,77.56) 179.95,77.73 R359.1 180.6,78.97 180.6,80.36 180.38,80.57 C184.1 180.67,81.34 180.67,83.53 180.29,83.91 179.88,83.91 179.75,84.04 CON11.7
ACC_INT2_IO: length 41.2
  TOP w0.102: U17.9 160.59,84.68 160.76,84.85 160.76,85.29 160.2,85.84 158.22,85.84 157,84.62 157,80.08 158.41,78.67 158.41,77.98 v2(158.93,77.46) 158.41,76.94 158.41,74.73 v1(159.46,73.68)
  IN1 w0.127: v1(159.46,73.68) 159.84,73.3 161.8,73.3 162.87,74.36 168.3,74.36 169.24,75.3 171.84,75.3 172.39,75.86 178.06,75.86 v1(178.39,75.53)
  BOTTOM w0.102: v1(178.39,75.53) 178.75,75.16 R358.2 ; U20.29 159.83,73.31 v1(159.46,73.68)
ACC_INT2_IO_R: length 11.8
  BOTTOM w0.102: CON11.6 179.25,84.07 179.66,83.66 179.91,83.66 180.29,83.28 180.29,81.65 179.63,80.99 179.47,80.99 C183.1 178.63,80.15 178.63,79.16 178.6,79.13 178.6,77.14 179.02,76.73 R358.1 177.92,76 v2(177.67,75.76)
ACZ_SDIN0: length 101.6
  TOP w0.102: v1(5.23,87.8) 5.12,87.9 v2(4.45,87.9)
  IN3 w0.102: v1(5.23,87.8) 5.73,88.3 6.06,88.3 6.69,87.67 7.47,87.67 7.88,88.08 10.77,88.08 11.03,87.83 11.03,87.24 11.96,86.3 14.1,86.3 14.81,85.6 17.57,85.6 20.3,88.33 22.2,88.33 23.81,89.94 42.05,89.94 43.25,88.75 51.29,88.75 52.49,89.94 56.13,89.94 v1(57.29,88.77)
  BOTTOM w0.089: 47.75,62.5 47.61,62.5 47.48,62.37 43.7,62.37 43.5,62.18 U1.AY10
  BOTTOM w0.102: CON10.34 5.17,87.74 v1(5.23,87.8) ; 47.75,62.5 48.19,62.5 48.57,62.88 48.57,65.63 48.66,65.71 49.08,65.71 50.06,66.69 51.89,66.69 52.17,66.98 54.55,66.98 55.19,67.62 56.25,67.62 56.55,67.62 57.55,68.63 57.55,68.63 57.97,69.04 57.97,81.38 58.49,81.89 58.49,87.76 59.21,88.49 59.21,88.99 58.95,89.25 57.77,89.25 v1(57.29,88.77)
ADAP_ID_VOL_D: length 5.1
  TOP w0.102: v2(161.27,42.74) 161.27,42.74 R345.2 161.27,41 161.26,40.99 Q36.1 162.51,39.98 162.52,39.97 Q37.3
ADAP_ID_VOL_G: length 6.4
  TOP w0.102: Q37.1 162.62,37.12 162.98,36.76 R346.1 ; R346.1 163.41,35.86 164.11,35.86 165.63,37.38 v2(165.84,37.38) ; R346.1 R344.2
ALL_SYSTEM_PWRGD: length 38.6
  TOP w0.102: v1(129.25,86.61) 129.71,87.06 130.06,87.06 130.35,86.77 130.35,86.4 130.07,86.12 130.07,83.81 130.38,83.51 131.07,83.51 131.29,83.28 131.29,81.42 132.31,80.41 132.31,77.38 134.58,75.11 136.39,75.11 T9200.1 137,74.5 R410.1 R60469.2
  IN1 w0.102: v1(129.25,86.61) 128.21,85.56 126.06,85.56 125.54,86.09 125.54,87.16 125.17,87.53 124.75,87.53 124.13,88.16 121.2,88.16 120.71,87.66 119.46,87.66 118.8,88.32 116.63,88.32 v1(116.17,87.86)
  BOTTOM w0.102: U10.68 115.34,86.93 116.17,87.76 v1(116.17,87.86)
AUDIO MODE: length 63.8
  TOP w0.102: v2(7.75,87.39) 7.57,87.39 v1(6.81,88.16)
  IN1 w0.102: v1(33.79,80.81) 32.89,80.81 32.45,80.37 29.61,80.37 29.16,79.93 26.77,79.93 26.19,79.34 23.23,79.34 22.64,79.92 21.61,79.92 20.22,78.53 20.22,77.06 18.66,75.49 14.59,75.49 13.96,74.86 11.67,74.86 11.43,74.62 10.86,74.62 10.38,74.13 7.81,74.13 7.15,73.47 5.61,73.47 3.57,75.52 3.57,79.22 3.8,79.45 3.8,89.29 4.6,90.09 6.38,90.09 6.81,89.65 v1(6.81,88.16)
  BOTTOM w0.102: R60464.2 32.42,75.28 32.56,75.42 32.56,76.81 33.34,77.59 33.34,79.32 33.79,79.77 v1(33.79,80.81) ; v1(6.81,88.16) 6.9,88.24 CON10.3
AUDIO MODE_R: length 7.7
  BOTTOM w0.089: U1.Y1 31.29,67.99 31.29,68.09 30.88,68.51 30.88,68.93
  BOTTOM w0.102: 30.88,68.93 30.88,70.61 31.36,71.09 31.84,71.09 32.35,71.59 32.56,71.59 R9330.2 32.47,72.36 32.47,73.09 32.42,73.14 R60464.1
AZ_BITCLK: length 88
  TOP w0.102: v2(7.14,89.1) v1(5.84,89.1)
  IN3 w0.102: v1(58.13,88.78) 58.13,89.72 57.19,90.65 52.19,90.65 51,89.46 43.54,89.46 42.35,90.65 23.51,90.65 21.9,89.05 20.01,89.05 18.05,87.09 12.24,87.09 11.74,87.59 11.74,88.28 11.23,88.79 7.93,88.79 7.62,89.1 v1(5.84,89.1)
  BOTTOM w0.102: v1(58.13,88.78) 58.13,82.04 57.62,81.53 57.62,69.19 57.41,68.98 56.4,67.97 55.04,67.97 54.4,67.33 53.65,67.33 53.41,67.57 AC1.1 52.39,67.43 52.03,67.43 51.87,67.28 AR1.2 ; CON10.31 5.44,89.49 v1(5.84,89.1)
AZ_RST#: length 99
  TOP w0.102: v1(54.46,68.04) 55.17,67.33 v2(55.17,67) 55.17,65.19 54.34,64.37 54.34,62.36 53.7,61.71 53.7,60.89 52.86,60.05 52.86,57.96 52.33,57.43 52.33,56.86 51.78,56.31 50.29,56.31 AC3.1 49.11,56.51 AR3.2
  IN3 w0.102: v1(57.7,87.93) 57.71,87.94 57.71,89.63 57.05,90.3 52.34,90.3 51.15,89.1 43.4,89.1 42.2,90.3 23.66,90.3 22.05,88.69 20.15,88.69 18.2,86.73 12.09,86.73 11.38,87.44 11.38,88.13 11.08,88.43 7.72,88.43 7.5,88.66 5.48,88.66 v1(5.26,88.43)
  BOTTOM w0.102: v1(54.46,68.04) 54.75,68.33 56.25,68.33 57.26,69.34 57.26,81.67 57.72,82.13 57.72,87.91 v1(57.7,87.93) ; CON10.33 5.07,88.24 v1(5.26,88.43)
AZ_SDATA_OUT_R: length 95.9
  TOP w0.102: v2(4.27,86.1) 4.27,86.37 5.14,87.24 v1(5.56,87.24)
  IN3 w0.102: v1(5.56,87.24) 5.89,87.24 6.16,86.98 7.28,86.98 7.95,87.65 10.47,87.65 10.67,87.44 10.67,87.09 11.84,85.92 13.98,85.92 14.66,85.24 17.71,85.24 20.45,87.98 22.35,87.98 23.95,89.59 39.14,89.59 40.34,88.39 51.44,88.39 52.63,89.59 55.85,89.59 v1(56.66,88.77)
  BOTTOM w0.102: CON10.35 5.56,87.24 v1(5.56,87.24) ; AR4.2 49.79,64.74 49.6,64.74 AC4.1 49.86,65.99 52.61,65.99 53.24,66.62 54.69,66.62 55.34,67.26 56.11,67.26 56.7,67.26 57.7,68.27 58.33,68.89 58.33,81.23 58.84,81.75 58.84,87.61 59.59,88.36 59.59,89.22 59.21,89.6 57.49,89.6 v1(56.66,88.77)
AZ_SYNC: length 94.2
  TOP w0.102: AR2.2 49.53,57.8 49.73,58 AC2.1 50.48,57.45 51.14,57.45 52.15,58.45 52.15,60.34 52.99,61.18 52.99,64.28 53.3,64.6 v2(53.3,65.9) 53.82,66.43 v1(53.82,67.94)
  IN3 w0.102: v1(56.02,88.77) 55.57,89.23 52.78,89.23 51.59,88.04 40.19,88.04 39,89.23 24.1,89.23 22.49,87.62 20.6,87.62 17.86,84.89 14.51,84.89 13.91,85.49 11.77,85.49 10.63,86.62 5.26,86.62 v1(5.19,86.69)
  BOTTOM w0.102: v1(56.02,88.77) 57.36,87.43 57.36,82.28 56.9,81.82 56.9,69.48 56.11,68.69 54.51,68.69 53.82,68 v1(53.82,67.94) ; v1(5.19,86.69) 5.14,86.74 CON10.36
B_DE: length 6.9
  TOP w0.102: v2(184.71,50.61) 182.97,50.61 R386.2 182.13,50.59 180.72,50.59 R388.1 179.15,51.02 178.76,51.4 U21.8
B_EQ1: length 6
  TOP w0.102: R379.2 170.68,48.92 v2(170.64,48.89) 172.09,48.89 172.32,49.12 172.71,49.12 R383.1 174,50.4 U21.20
B_EQ2: length 8.5
  TOP w0.102: R382.1 172.91,53.48 171.24,53.48 R378.2 ; R382.1 174.49,51.9 U21.17 ; R382.1 173.8,53.26 174.17,53.26 174.68,53.77 174.68,54.12 173.73,55.06 v2(173.61,55.06)
BACK_EN_C: length 80.4
  TOP w0.102: R293.1 172.18,17.76 171.64,17.23 171.64,15.92 v1(172.09,15.47) R291.1 ; v2(155.98,32.35) 155.98,31.77 156.52,31.24 v1(156.52,30.97) 156.98,30.97 157.6,30.35 R290.1
  IN1 w0.102: v1(156.52,30.97) 158.23,30.97 158.9,31.64 164.77,31.64 167.01,33.88 167.01,36.98 167.46,37.43 170.56,37.43 170.73,37.6 176.06,37.6 v1(176.35,37.89)
  IN2 w0.102: v1(172.09,15.47) 171.43,14.81 169.75,14.81 168.59,15.98 153.71,15.98 v1(153.65,15.92)
  BOTTOM w0.102: v1(172.09,15.47) 170.07,13.45 166.6,13.45 165.05,11.9 165.05,10.13 165.25,9.93 P2.36 ; v1(156.52,30.97) 156.72,30.77 156.72,29.28 154.4,26.95 154.4,20.41 153.21,19.23 153.21,16.35 v1(153.65,15.92) ; VU4.4 v1(176.35,37.89)
BAT1_IN_OC#: length 81.8
  TOP w0.102: PQ9.6 136.18,38.79 136.42,38.55 137.51,38.55 138.23,39.28 138.23,41.93 138.95,42.65 141.7,42.65 v1(141.91,42.87) ; v1(129.81,68.31) 129.06,69.06 T58.1 129.06,74.24 127.66,75.63 v1(127.66,77.94) ; v1(110.19,80.23) 110,80.04 R199.2
  IN1 w0.102: v1(127.66,77.94) 128.06,78.34 128.06,79.99 127.59,80.46 112.74,80.46 112,79.72 110.69,79.72 v1(110.19,80.23)
  IN3 w0.102: v1(141.91,42.87) 142.7,43.65 142.7,46.11 141.7,47.1 141.7,53.79 140.73,54.77 140.25,54.77 136.63,58.39 134.1,58.39 133.99,58.49 131.33,58.49 130.18,59.64 130.18,65.03 129.33,65.87 129.33,67.83 v1(129.81,68.31)
  BOTTOM w0.102: U10.86 112.69,79.73 111.77,80.65 110.61,80.65 v1(110.19,80.23)
BAT_ALERT: length 5.8
  TOP w0.102: v1(125.53,79.34) 125.5,79.32 T51.1
  BOTTOM w0.102: CON8.7 124.01,77.82 v1(125.53,79.34)
BATLOW#: length 10.1
  TOP w0.089: v1(38.86,65.35) 39.26,64.95 40.63,64.95 v2(40.88,64.7) 41.72,64.7 44.71,67.68 44.98,67.68 45.65,68.34 PR30.2
  BOTTOM w0.089: U1.AN4 39.01,65.51 v1(38.86,65.35)
BBS_BIT0: length 7.5
  BOTTOM w0.089: U1.J2 25.49,67.32 25.2,67.6 25.2,68.13 24.51,68.83 24.51,69.82
  BOTTOM w0.102: 24.51,69.82 24.51,70.79 R103.1 24.29,71.84 24.29,73.03 R71.2
BBS_BIT1: length 12.6
  TOP w0.102: v1(22.48,75.84) 21.99,76.32 R416.2 22.66,77.21 22.66,77.79 23.12,78.25 v2(23.12,78.71)
  BOTTOM w0.089: 23.6,70.65 24.09,70.17 24.09,68.74 24.74,68.09 U1.G1
  BOTTOM w0.102: v1(22.48,75.84) 22.53,75.79 22.53,73.72 22.38,73.57 22.38,72 R106.1 22.96,71.29 23.6,70.65
BIST_EN: length 168.7
  TOP w0.102: R285.2 v2(152.54,13.45) 153.18,14.09 153.18,16.08 v1(153.65,16.55)
  IN1 w0.102: v1(129.62,87.61) 130.35,86.87 130.35,85.84 129.8,85.29 126,85.29 125.34,85.95 125.34,87.08 125.09,87.33 124.63,87.33 124,87.95 121.29,87.95 120.79,87.46 119.38,87.46 118.72,88.11 117.08,88.11 116.36,87.39 115.04,87.39 114.78,87.65 112.09,87.65 111.48,87.04 109.35,87.04 109.07,87.32 109.07,87.67 108.82,87.93 106.1,87.93 105.84,87.67 101.49,87.67 v1(100.82,88.35)
  IN2 w0.102: v1(129.62,87.61) 129.62,88.07 129.99,88.45 149.62,88.45 v1(152.96,85.11)
  IN3 w0.102: v1(152.96,85.11) 153.62,84.45 157.79,84.45 157.94,84.29 163.45,84.29 164.62,83.13 164.62,82.49 168.73,78.37 168.73,72.81 168.14,72.22 168.14,49.41 170,47.54 170,45.23 170.63,44.61 170.63,41.99 v1(170,41.37)
  BOTTOM w0.102: v1(153.65,16.55) 154.19,16.01 164.63,16.01 167.99,19.36 170.77,19.36 173.82,22.41 173.82,32.02 173.18,32.66 173.18,34.46 172.6,35.04 172.6,39.29 170.52,41.37 v1(170,41.37) ; U10.35 101.38,88.91 v1(100.82,88.35)
BKLT_CTRL: length 38.8
  TOP w0.102: R286.2 v1(164.89,17.06) 165.15,17.32 v2(165.15,17.85) 165.15,18.23 164.89,18.49 U6.47
  IN3 w0.102: v1(181.36,36.95) 178.6,34.19 178.6,31.75 175.27,28.43 175.27,17.49 172.6,14.81 170.23,14.81 169.12,15.92 167.62,15.92 166.47,17.06 v1(164.89,17.06)
  BOTTOM w0.102: VU3.2 v1(181.36,36.95)
BL_EN: length 28.9
  TOP w0.102: R290.2 157.6,28.47 v1(157.68,28.39) 158.11,27.96 v2(158.31,27.96) 158.88,27.4 159.39,27.4 159.69,27.09 U6.15
  IN3 w0.102: v1(175.41,32.68) 172.24,32.68 167.62,28.06 163.32,28.06 163.01,27.74 158.1,27.74 157.68,28.16 v1(157.68,28.39)
  BOTTOM w0.102: VU4.2 175.02,36.94 175.41,36.54 v1(175.41,32.68)
CAM_DET_CBL#: length 150.9
  IN1 w0.102: v1(157.94,80.51) 156.39,80.51 155.65,79.77 151.44,79.77 149.61,77.94 135.32,77.94 135.05,78.22 134.25,78.22 v1(133.85,77.82)
  IN2 w0.089: v1(32.09,65.35) 32.09,65.57 31.91,65.75 31.91,67.31 32.16,67.56 32.16,70.93
  IN2 w0.102: v1(133.85,77.82) 133.85,77.54 132.55,76.24 117.83,76.24 116.18,74.59 114.18,74.59 113.82,74.96 113.82,75.79 112.83,76.78 109.08,76.78 108.79,77.07 102.69,77.07 102.35,77.41 99.98,77.41 99.15,76.57 96.75,76.57 95.78,77.54 90.16,77.54 88.94,76.32 64.84,76.32 63.87,75.35 59.2,75.35 58.23,76.32 53.86,76.32 53.59,76.05 49.9,76.05 49.2,76.75 48.72,76.75 48.44,76.48 45.75,76.48 44.83,77.4 43.71,77.4 42.83,76.52 34.45,76.52 34.06,76.13 34.06,75.35 32.16,73.45 32.16,70.93
  BOTTOM w0.089: U1.Y3 31.52,66.44 31.87,66.1 31.87,65.57 v1(32.09,65.35)
  BOTTOM w0.102: v1(157.94,80.51) 157.94,81.15 157.46,81.63 157.46,81.81 157.64,81.99 CON6.11 159.46,81.99 159.46,82 SR77.2 R144.1 160.76,82.75 v2(160.99,82.97)
CATERR#: length 149.6
  TOP w0.102: R244.1 108.54,68.75 108.42,68.75 v1(108.19,68.52) 108.22,68.5 110.49,68.5 110.71,68.28 112.31,68.28 HT98.1
  IN2 w0.089: 27.48,30.57 27.48,31.43 28.08,32.02 30.23,32.02 30.84,32.63 31.57,32.63 31.68,32.53 33.4,32.53 34.01,31.92 34.18,31.92 34.72,31.38 34.72,29.61 35.92,28.41 35.92,26.92 36.63,26.2 36.63,25.46 37.87,24.22 41.38,24.22
  IN2 w0.102: 27.48,30.57 27.09,30.18 v1(26.57,30.18) ; v1(90.07,56.23) 89.65,55.81 89.65,55.2 89.41,54.96 89.41,48.71 90.53,47.59 90.53,23.23 88.16,20.87 88.16,19.37 85.58,16.78 77.42,16.78 75.58,14.94 67.38,14.94 64.54,17.78 57.57,17.78 57.19,17.4 48.96,17.4 48.29,18.07 48.29,19.02 45.78,21.53 44.02,21.53 43.56,21.99 43.56,22.92 42.26,24.22 41.38,24.22
  IN3 w0.102: v1(108.19,68.52) 106.21,68.52 105.39,67.7 95.99,67.7 95.23,66.93 94.16,66.93 92.61,65.38 92.61,57.02 91.45,55.87 90.43,55.87 v1(90.07,56.23)
  BOTTOM w0.089: v1(26.57,30.18) 26.27,30.48 U1.K61
CFG0: length 75.9
  TOP w0.102: v1(68.96,7.51) 69.28,7.2 XDP1.9 ; HR37.2 38.45,24.54 v2(39.17,25.26) 38.41,26.03 38.41,28.92 37.01,30.32 35.21,30.32 v1(34.07,31.47)
  IN2 w0.089: 34.47,25.46 34.47,31.07 v1(34.07,31.47) ; 42.99,22.92 42.42,23.49
  IN2 w0.102: 34.47,25.46 34.47,25.46 37.78,22.14 39.52,22.14 40.87,23.49 42.42,23.49 ; 42.99,22.92 42.99,21.74 43.6,21.13 45.61,21.13 47.76,18.98 47.76,17.93 48.69,17 57.35,17 57.74,17.38 64.11,17.38 69.46,12.03 69.46,11.84 72.33,8.97 72.33,7.25 71.96,6.89 70.8,6.89 70.18,7.51 v1(68.96,7.51)
  BOTTOM w0.089: U1.AC60 33.32,31.47 v1(34.07,31.47)
CFG1: length 65.9
  TOP w0.089: v2(32.35,28.96) 32.24,28.84 32.24,28 v1(32.68,27.55)
  TOP w0.102: XDP1.11 69.78,6.34 v1(70.94,7.51) ; v1(32.68,27.55) 32.68,26.64 34.01,25.32 35.75,25.32 HR38.2
  IN2 w0.089: 40.98,21.86 37.8,21.86 34.19,25.47 34.19,26.05 v1(32.68,27.55)
  IN2 w0.102: v1(70.94,7.51) 71.36,7.09 71.88,7.09 72.12,7.34 72.12,7.68 68.52,11.29 68.52,12.29 63.63,17.17 57.82,17.17 57.44,16.79 48.61,16.79 47.55,17.85 47.55,18.89 45.53,20.92 41.92,20.92 40.98,21.86
  BOTTOM w0.089: v1(32.68,27.55) 33.04,27.91 33.04,28.7 33.22,28.88 33.22,29.54 U1.AC62
CFG2: length 80.4
  TOP w0.102: HT14.1 53.74,2.24 60.36,2.24 60.86,2.74 63.85,2.74 67.34,6.23 67.37,6.23 68.54,7.4 68.54,7.68 68.79,7.93 71.29,7.93 v1(71.71,7.51) 70.78,6.58 XDP1.15
  IN2 w0.089: 33.31,22.83 33.31,26.36 32.28,27.39 32.28,27.84 v1(32.64,28.2)
  IN2 w0.102: 33.31,22.83 33.31,22.03 34.23,21.11 40.82,21.11 41.87,20.05 45.06,20.05 48.52,16.59 57.52,16.59 57.9,16.97 63.55,16.97 68.32,12.21 68.32,9.98 69.89,8.4 70.82,8.4 v1(71.71,7.51)
  BOTTOM w0.089: U1.AC63 32.94,28.85 32.64,28.55 v1(32.64,28.2)
CFG3: length 83
  TOP w0.102: v1(85.1,14.32) 85.73,14.32 HT15.1 85.75,13.43 GR22.2 ; v1(72.85,7.51) 72.34,7.51 71.28,6.44 XDP1.17
  IN2 w0.089: v1(31.27,27.31) 31.85,26.73 31.85,22.9 31.78,22.83
  IN2 w0.102: v1(85.1,14.32) 84.46,14.95 80.98,14.95 80.47,14.44 80.47,11.73 76.25,7.51 v1(72.85,7.51) 72.85,7.31 72.23,6.68 68.88,6.68 68.73,6.84 66.86,6.84 66.36,7.34 66.36,8.86 67.04,9.54 67.04,9.92 63.87,13.1 61.49,13.1 59.52,15.07 48.9,15.07 44.72,19.24 41.53,19.24 40.51,20.27 33.63,20.27 31.78,22.12 31.78,22.83
  BOTTOM w0.089: v1(31.27,27.31) 31.61,27.65 31.88,27.92 31.88,28.59 32.19,28.9 U1.AA63
CFG3_R: length 7.9
  TOP w0.102: XDP1.60 81.78,11.33 82.25,11.8 84.36,11.8 GR22.1 85.42,12.54 v2(87.33,10.63)
CFG4: length 68.8
  TOP w0.089: v1(31.27,26.03) 31.95,25.34 HR39.2
  TOP w0.102: XDP1.27 73.78,5.74 v1(73.84,5.81)
  IN2 w0.089: v1(31.27,26.03) 30.4,25.16 30.4,22.83
  IN2 w0.102: v1(73.84,5.81) 73.17,6.48 68.55,6.48 68.4,6.63 66.77,6.63 64.98,8.42 64.19,8.42 63.52,9.1 63.52,10.27 64.07,10.82 64.07,11.5 63.09,12.49 58.71,12.49 56.79,14.41 47.12,14.41 42.89,18.63 41.28,18.63 40.26,19.65 32.82,19.65 30.4,22.07 30.4,22.83
  BOTTOM w0.089: U1.AA60 31.83,30.8 31.83,29.74 32.09,29.47 32.3,29.47 32.48,29.29 32.48,28.94 32.06,28.52 32.06,26.66 v2(32.56,26.15) 32.56,25.8 32.34,25.57 31.73,25.57 v1(31.27,26.03)
CFG5: length 79.2
  TOP w0.102: HT16.1 55.36,2.44 60.28,2.44 60.78,2.94 63.59,2.94 66.58,5.93 66.58,7.32 v1(66.78,7.51) 67.2,7.09 67.95,7.09 68.34,7.48 68.34,7.77 68.7,8.13 73.05,8.13 74.28,6.91 XDP1.29
  IN2 w0.089: 32.03,22.83 32.03,26.84 31.73,27.14 31.73,27.49 v1(31.27,27.95)
  IN2 w0.102: v1(66.78,7.51) 66.78,7.82 67.25,8.28 67.25,10 63.95,13.3 61.57,13.3 59.6,15.27 48.98,15.27 44.81,19.44 41.62,19.44 40.59,20.47 33.72,20.47 32.03,22.16 32.03,22.83
  BOTTOM w0.089: v1(31.27,27.95) 31.28,27.94 31.53,27.94 31.7,28.11 31.7,28.9 31.8,29 31.8,29.47 U1.Y62
CFG6: length 90.6
  TOP w0.102: XDP1.33 75.28,5.29 v1(74.75,5.81) 74.75,6.72 73.14,8.34 68.62,8.34 68.14,7.85 68.14,7.57 67.87,7.29 67.52,7.29 67.26,7.55 67.26,7.98 67.1,8.15 66.52,8.15 65.94,7.56 65.94,5.57 63.51,3.14 60.69,3.14 60.2,2.65 56.94,2.65 HT20.1
  IN2 w0.089: 30.2,22.83 30.2,25.54 30.87,26.21 30.87,29 31.07,29.2 v1(31.07,30.18)
  IN2 w0.102: 30.2,22.83 30.2,21.99 32.73,19.45 40.17,19.45 41.2,18.43 42.81,18.43 47.03,14.2 56.71,14.2 58.62,12.29 63,12.29 63.87,11.42 63.87,10.91 63.32,10.35 63.32,9.01 64.16,8.17 64.95,8.17 66.69,6.43 68.32,6.43 68.47,6.28 72.46,6.28 72.76,5.98 72.76,5.63 73.01,5.39 74.33,5.39 v1(74.75,5.81)
  BOTTOM w0.089: U1.Y61 31.37,30.48 v1(31.07,30.18)
CFG7: length 79
  TOP w0.102: HT22.1 58.94,3.14 59.01,3.08 60.34,3.08 60.61,3.34 63.43,3.34 65.74,5.66 65.74,7.69 66.45,8.4 67.49,8.4 67.69,8.2 v1(67.69,7.71) 68.52,8.54 73.22,8.54 75.34,6.42 75.34,5.61 75.78,5.17 XDP1.35
  IN2 w0.089: v1(32.56,31.47) 31.93,30.84 31.93,27.24 32.39,26.78 32.39,23.94 32.91,23.42 32.91,22.83
  IN2 w0.102: 32.91,22.83 32.91,21.86 34.09,20.67 40.67,20.67 41.7,19.65 44.89,19.65 49.07,15.47 59.69,15.47 61.65,13.5 64.03,13.5 67.64,9.9 67.64,7.76 v1(67.69,7.71)
  BOTTOM w0.089: v1(32.56,31.47) 31.82,31.47 U1.Y60
CFG8: length 60.7
  TOP w0.089: HR40.2 32.83,24.81 32.74,24.81 31.68,25.87 31.68,26.26 v1(31.27,26.66)
  TOP w0.102: XDP1.10 69.28,11.4 69.46,11.59 69.46,12.21 69.01,12.65 66.96,12.65 66.02,11.71 v1(66.02,10)
  IN2 w0.089: 30.9,22.83 30.9,23.52 31.67,24.29 31.67,26.26 v1(31.27,26.66)
  IN2 w0.102: 30.9,22.83 30.9,22.14 32.99,20.06 40.43,20.06 41.45,19.04 44.55,19.04 48.72,14.86 59.43,14.86 61.4,12.9 63.33,12.9 65.99,10.24 65.99,10.02 v1(66.02,10)
  BOTTOM w0.089: v2(30.67,25.7) 30.67,26.06 v1(31.27,26.66) 30.81,27.12 30.81,28.77 31.01,28.97 31.01,29.5 U1.V62
CFG9: length 65.3
  TOP w0.102: XDP1.12 69.78,12.56 69.48,12.86 66.71,12.86 65.3,11.45 63.7,11.45 v1(63.45,11.19) ; v1(31.08,30.81) 31.68,30.22 31.68,26.56 v2(32.54,25.7) 33.21,25.02 33.76,25.02 HR41.2
  IN2 w0.089: v1(31.08,30.81) 30.66,30.39 30.66,26.25 29.99,25.58 29.99,22.83
  IN2 w0.102: 29.99,22.83 29.99,21.9 32.65,19.25 40.09,19.25 41.11,18.22 42.72,18.22 46.95,14 56.59,14 58.51,12.08 62.92,12.08 63.45,11.55 v1(63.45,11.19)
  BOTTOM w0.089: U1.V61 30.75,30.48 v1(31.08,30.81)
CFG10: length 69.7
  TOP w0.089: 31.88,27.17 31.88,31.28 31.95,31.36 v2(31.95,31.84) 31.47,31.84 v1(31.08,31.45)
  TOP w0.102: XDP1.16 70.78,12.33 70.04,13.06 66.63,13.06 65.22,11.65 63.27,11.65 v1(62.82,11.19) ; 31.88,27.17 33.94,25.11 34.81,25.11 HR42.2
  IN2 w0.089: v1(31.08,31.45) 30.48,30.85 30.48,26.32 29.79,25.63 29.79,22.83
  IN2 w0.102: 29.79,22.83 29.79,21.82 32.57,19.04 40.01,19.04 41.03,18.02 42.64,18.02 46.86,13.8 56.5,13.8 58.45,11.85 62.46,11.85 62.82,11.5 v1(62.82,11.19)
  BOTTOM w0.089: U1.V60 30.75,31.13 v1(31.08,31.45)
CFG11: length 69.1
  TOP w0.102: v1(57.33,9.62) 57.75,10.04 57.8,10.04 58.83,11.07 59.01,11.07 59.79,11.85 65.1,11.85 66.51,13.26 70.37,13.26 71.28,12.36 XDP1.18
  IN2 w0.089: 27.8,22.83 27.8,28.91
  IN2 w0.102: v1(57.33,9.62) 57.3,9.64 48.06,9.64 41.52,16.19 30.26,16.19 29.33,17.13 29.33,20.08 27.8,21.6 27.8,22.83 ; 27.8,28.91 28.92,30.03 28.92,31.26 29.14,31.47 v1(29.57,31.47)
  BOTTOM w0.089: U1.U60 29.63,31.47 v1(29.57,31.47)
  BOTTOM w0.102: HT25.1 54.59,8.22 55.81,9.44 57.15,9.44 v1(57.33,9.62)
CFG12: length 63.8
  TOP w0.102: XDP1.28 73.78,12.13 73.44,12.46 72.56,12.46 71.15,13.87 66.24,13.87 64.83,12.46 58.42,12.46 57.47,11.51 54.57,11.51 HT27.1 54.13,11.35 v1(53.29,10.51)
  IN2 w0.089: v1(28.62,27.33) 28.23,26.94 28.23,22.83
  IN2 w0.102: 28.23,22.83 28.23,21.75 29.76,20.22 29.76,17.27 30.43,16.6 41.8,16.6 46.03,12.37 51.42,12.37 v1(53.29,10.51)
  BOTTOM w0.089: v1(28.62,27.33) 28.63,27.33 29.36,28.07 29.36,29.01 U1.T63
CFG13: length 62.5
  TOP w0.089: HT28.1 30.61,26.7 v1(30.02,27.29)
  TOP w0.102: v1(56.44,11.93) 56.66,12.15 57.77,12.15 58.29,12.67 64.74,12.67 66.15,14.08 71.23,14.08 72.64,12.67 73.53,12.67 74.28,11.92 XDP1.30
  IN2 w0.089: v1(30.02,27.29) 30.02,27.31 29.61,26.91 29.61,23.33 29.47,23.18
  IN2 w0.102: 29.47,23.18 29.47,21.68 32.33,18.81 32.94,18.81 34.34,17.41 42.32,17.41 46.54,13.19 55.64,13.19 56.44,12.39 v1(56.44,11.93)
  BOTTOM w0.089: U1.T62 29.54,29.48 29.54,27.79 30.02,27.31 v1(30.02,27.29)
CFG14: length 66.3
  TOP w0.089: HT30.1 29.58,30.18 v1(29.57,30.18)
  TOP w0.102: XDP1.34 75.28,11.84 74.71,12.4 74.08,12.4 73.61,12.87 72.73,12.87 71.32,14.28 66.07,14.28 64.66,12.87 58.2,12.87 57.68,12.35 55.79,12.35 v1(55.37,11.93)
  IN2 w0.089: 28.43,22.83 28.43,25.02 29.06,25.65 29.06,28.16 29.57,28.67 v1(29.57,30.18)
  IN2 w0.102: 28.43,22.83 28.43,21.84 29.96,20.31 29.96,18.33 31.49,16.8 41.89,16.8 46.11,12.58 54.73,12.58 v1(55.37,11.93)
  BOTTOM w0.089: U1.T61 29.27,30.48 v1(29.57,30.18)
CFG15: length 68.6
  TOP w0.089: HT31.1 29.94,31.18 29.57,30.81 v1(29.57,30.81)
  TOP w0.102: v1(51,11.93) 51.63,12.55 57.6,12.55 58.12,13.07 64.57,13.07 65.23,13.73 65.98,14.48 71.4,14.48 72.81,13.07 73.7,13.07 74.04,12.73 75.2,12.73 75.78,12.15 XDP1.36
  IN2 w0.089: 28.01,22.83 28.01,28.67 29.12,29.78 29.12,30.36 v1(29.57,30.81)
  IN2 w0.102: v1(51,11.93) 46.06,11.93 41.6,16.39 30.35,16.39 29.53,17.21 29.53,20.16 28.01,21.69 28.01,22.83
  BOTTOM w0.089: v1(29.57,30.81) 29.26,31.13 U1.T60
CFG16: length 60.5
  TOP w0.102: v1(66.63,9.75) 66.65,9.77 66.65,12.06 67.04,12.45 68.07,12.45 68.32,12.21 68.32,11.62 68.28,11.58 XDP1.6
  IN2 w0.089: v1(31.27,25.32) 31.27,24.38 30.62,23.73 30.62,22.83
  IN2 w0.102: 30.62,22.83 30.62,22.14 32.9,19.85 40.34,19.85 41.37,18.83 42.98,18.83 47.2,14.61 56.88,14.61 58.79,12.69 63.17,12.69 65.57,10.29 65.57,9.85 65.84,9.58 66.46,9.58 v1(66.63,9.75)
  BOTTOM w0.089: 32.5,25.37 33.04,25.91 33.04,26.29 33.02,26.31 33.02,26.65 32.23,27.44 32.23,28.44 32.65,28.86 32.65,29.37 32.32,29.7 32.32,29.7 U1.AA62
  BOTTOM w0.102: 32.5,25.37 32.45,25.32 v1(31.27,25.32) 30.98,25.02 30.81,25.02 29.92,24.14 HT34.1
CFG17: length 52.1
  TOP w0.102: XDP1.4 67.78,11.91 v1(67.9,12.03)
  IN2 w0.089: v1(32.56,30.18) 32.56,28.79 32.11,28.34 32.11,27.31 32.56,26.85 32.56,24.05 33.11,23.5 33.11,22.83
  IN2 w0.102: v1(67.9,12.03) 67.48,11.61 66.33,11.61 64.11,13.83 61.73,13.83 59.18,16.39 48.44,16.39 44.98,19.85 41.79,19.85 40.73,20.9 34.15,20.9 33.11,21.94 33.11,22.83
  BOTTOM w0.089: U1.AA61 32.26,30.48 v1(32.56,30.18)
  BOTTOM w0.102: HT36.1 67.03,11.17 v1(67.9,12.03)
CFG18: length 64.1
  TOP w0.102: v1(54.56,10.51) 55.36,11.31 57.77,11.31 58.27,11.8 HT35.1 59.18,12.26 64.93,12.26 66.34,13.67 71.07,13.67 72.48,12.26 72.48,11.69 72.78,11.4 XDP1.24
  IN2 w0.089: 28.63,22.83 28.63,24.94 29.26,25.56 29.26,27.8 30,28.54 v1(30,28.57)
  IN2 w0.102: v1(54.56,10.51) 54.94,10.89 55.35,10.89 55.79,11.33 55.79,12.46 55.47,12.78 46.24,12.78 42.01,17 32.56,17 31.93,17.64 31.93,18.63 28.63,21.92 28.63,22.83
  BOTTOM w0.089: U1.U63 29.94,28.6 30,28.54 v1(30,28.57)
CFG19: length 63.5
  TOP w0.102: v1(55.58,10.51) 56.17,11.1 58.55,11.1 58.71,11.27 58.9,11.27 59.69,12.06 65.01,12.06 66.42,13.47 70.98,13.47 72.28,12.17 XDP1.22
  IN2 w0.089: 29.24,23.23 29.43,23.42 29.43,27.34 v1(30.02,27.92)
  IN2 w0.102: v1(55.58,10.51) 56,10.93 56,12.54 55.56,12.98 46.42,12.98 42.19,17.21 34.26,17.21 32.85,18.61 32.23,18.61 29.24,21.61 29.24,23.23
  BOTTOM w0.089: U1.U62 30.28,29.49 30.28,29.06 30.45,28.89 30.45,28.36 30.33,28.24 v1(30.02,27.92)
  BOTTOM w0.102: HT38.1 54.53,11.56 v1(55.58,10.51)
CFG_RCOMP: length 6
  TOP w0.089: HR44.1 30.01,25.34 30.01,26.06
  TOP w0.102: 30.01,26.06 v1(30.01,26.65)
  BOTTOM w0.089: v2(29.4,26.96) 29.7,26.96 v1(30.01,26.65) 30.01,26.66 30.43,27.08 30.43,27.78 30.63,27.98 30.63,29.12 U1.V63
CHG_ACDRV_A: length 3.1
  TOP w0.254: v1(138.89,48.61) 139.4,48.1 v2(139.4,48.07)
  BOTTOM w0.254: PR75.2 138.66,48.38 v1(138.89,48.61) 139.53,48.61 139.79,48.86 PU3.4
CHG_ACDRV_A1: length 213.7
  TOP w0.381: v2(143.16,44.14) v1(143.16,45.08) ; PC55.2 5.87,61.14 5.87,66.92 6.55,67.61 PQ11.4 6.55,69.04 6.49,69.11 PC56.2 6.49,70.16 6.68,70.35 12.07,70.35 12.74,69.67 PQ12.3 13.12,70.29 v1(13.08,70.32)
  IN1 w0.381: v1(55.02,86.71) 55.02,84.9 58.75,81.17 61.83,81.17 62.21,80.79 65.49,80.79 67.97,78.31 67.97,77.44 68.89,76.52 70.6,76.52 72.22,78.15 82.76,78.15 84.05,76.85 89.57,76.85 90.41,77.69 93.46,77.69 95.91,75.24 95.91,74.01 97.84,72.08 97.84,70.45 101.17,67.12 101.17,64.6 104.31,61.46 106.31,61.46 107.13,60.63 107.13,54.99 107.55,54.57 107.55,49.12 106.53,48.1 106.53,37.35 108.09,35.78 v1(109.98,35.78)
  IN3 w0.381: v1(109.98,35.78) 112.57,38.37 124.46,38.37 125.38,39.29 125.95,39.29 126.13,39.46 133.43,39.46 135.92,41.95 135.92,42.7 v1(138.52,45.3) ; v1(55.02,86.71) 55.02,87.26 54.37,87.9 53.3,87.9 52.06,86.66 32.28,86.66 31.52,87.42 25.73,87.42 22.17,83.86 22.12,83.86 21.59,83.33 21.59,82.36 20.79,81.56 19.15,81.56 18.82,81.24 18.82,80.08 17.38,78.63 17.38,73.12 16.41,72.15 16.41,70.22 15.29,69.11 13.64,69.11 13.08,69.66 v1(13.08,70.32)
  BOTTOM w0.381: v1(143.16,45.08) 142.7,44.62 138.76,44.62 138.52,44.86 v1(138.52,45.3) 138.52,45.86 138.66,46 PR75.1
CHG_ACN_A: length 195.9
  TOP w0.102: v1(54.46,86.38) 54.46,85.95 v2(54.74,85.67)
  TOP w0.127: v1(17.18,67.48) 16.77,67.48 16.47,67.18 16.47,65.71 16.21,65.45 14.68,65.45 14.39,65.15 PJP3.1
  IN1 w0.127: v1(54.46,86.38) 54.46,84.96 58.7,80.71 61.65,80.71 62.19,80.18 64.73,80.18 68.74,76.17 70.79,76.17 72.32,77.69 82.5,77.69 83.69,76.5 89.72,76.5 90.55,77.32 93.05,77.32 94.87,75.5 94.87,74.35 97.46,71.76 97.46,70.15 99.26,68.35 99.26,50.2 102.11,47.36 102.11,42.63 105.97,38.77 105.97,37.4 107.95,35.42 109.63,35.42 v1(110.52,34.54)
  IN3 w0.127: v1(141.28,45.33) 140.74,44.8 140.31,44.8 138.78,43.27 138.78,40.73 137.44,39.39 136.01,39.39 133.38,36.75 114.46,36.75 112.45,34.74 110.72,34.74 v1(110.52,34.54) ; v1(54.46,86.38) 54.46,86.71 54.26,86.91 52.81,86.91 52.08,86.17 32.56,86.17 31.53,85.14 29.41,85.14 29.03,84.76 24.46,84.76 22.68,82.98 22.68,82.64 19.58,79.54 19.58,75.93 18.57,74.92 18.57,70.5 17.73,69.66 17.04,69.66 16.44,69.06 16.44,68.22 v1(17.18,67.48)
  BOTTOM w0.127: PU3.1 141.29,49.29 PC60.2 141.29,47.43 141.36,47.36 PC61.1 141.86,46.42 141.86,45.58 141.61,45.33 v1(141.28,45.33)
CHG_ACOK_A: length 6.6
  TOP w0.254: v2(136.22,45.64) v1(137.01,45.64)
  BOTTOM w0.254: PU3.5 138.46,49.29 137.6,48.44 PR90.1 138.13,47.31 138.13,46.2 PR83.2 137.56,45.64 v1(137.01,45.64)
CHG_ACP_A: length 194.4
  TOP w0.102: v1(53.82,86.48) 53.47,86.83 v2(52.83,86.83)
  TOP w0.127: PJP2.1 16.12,65.68 16.24,65.8 16.24,67.28 17.09,68.14 v1(17.18,68.14)
  IN1 w0.127: v1(53.82,86.48) 53.9,86.4 53.9,85.19 58.64,80.46 61.58,80.46 62.09,79.95 64.63,79.95 68.65,75.94 70.89,75.94 72.42,77.46 82.4,77.46 83.59,76.27 89.81,76.27 90.64,77.09 92.95,77.09 94.64,75.4 94.64,74.25 97.23,71.66 97.23,70.05 98.48,68.81 98.48,60.29 97.23,59.04 97.23,51.91 101.88,47.26 101.88,41.17 108.39,34.66 v1(109.75,34.66)
  IN3 w0.127: v1(53.82,86.48) 53.67,86.63 52.86,86.63 52.15,85.92 32.64,85.92 31.63,84.91 29.51,84.91 29.13,84.53 24.55,84.53 22.92,82.9 22.92,82.55 19.81,79.44 19.81,75.84 18.88,74.9 18.88,70.51 17.76,69.38 17.07,69.38 16.65,68.97 16.65,68.66 v1(17.18,68.14) ; v1(109.75,34.66) 110.09,34.99 112.32,34.99 114.31,36.98 133.28,36.98 135.92,39.62 137.35,39.62 138.55,40.82 138.55,43.36 139.89,44.7 v1(139.89,45.33)
  BOTTOM w0.127: v1(139.89,45.33) 139.97,45.41 139.97,46.36 PC57.1 140.52,47.33 140.45,47.4 PC60.1 140.79,48.14 PU3.2
CHG_BATDRV_A: length 3.6
  TOP w0.102: v2(139.5,52.67) 139.13,53.04 v1(139.13,53.4)
  BOTTOM w0.254: PU3.11 139.29,53.24 v1(139.13,53.4)
  BOTTOM w0.508: PR84.1 137.98,54.06 138.65,53.4 v1(139.13,53.4)
CHG_BATDRV_R_A: length 29.7
  TOP w0.102: v1(137.98,56.05) v2(137.98,56.86)
  IN1 w0.508: v1(136.67,67.85) 132.56,67.85 132.33,67.62 132.33,60.2 132.62,59.91 136.09,59.91 136.7,59.3 137.97,59.3 138.69,60.01 140.63,60.01 141.5,59.14 141.5,57.04 140.51,56.05 v1(137.98,56.05)
  BOTTOM w0.508: v1(137.98,56.05) PR84.2
CHG_BTST_D: length 5.6
  TOP w0.508: v2(144.63,54.98) 145.59,54.98 v3(145.67,54.91)
  IN2 w0.762: v3(143.24,51.85) 144.11,51.85 145.67,53.41 v3(145.67,54.91)
CHG_BTST_R_D: length 8.4
  TOP w0.508: v2(140.74,59.86) v3(140.74,58.84)
  IN2 w0.635: v3(145.58,57) 141.85,57 140.74,58.11 v3(140.74,58.84)
  BOTTOM w0.508: v3(145.58,57) 144.6,57 PR86.2
CHG_CMSRC_A: length 2.9
  TOP w0.254: v2(141.15,48.05) 140.81,48.05 v1(140.29,48.57)
  BOTTOM w0.254: PR76.2 v1(140.29,48.57) PU3.3
CHG_HIDRV_D: length 16.9
  TOP w0.635: v1(143.46,50.74) 144.58,51.86 144.58,52.21 146.76,54.4 146.76,57.24 145.49,58.51 v2(145.49,60.95) 144.86,61.59 144.86,63.17 v1(144.41,63.62)
  BOTTOM w0.254: PU3.18 143.21,50.89 143.36,50.74 v1(143.46,50.74)
CHG_ILIM_A: length 5.2
  TOP w0.254: v1(138.69,52.62) 138.33,52.98 138.33,53.17 137.76,53.74 v2(137.26,53.74) v1(137.26,54.5)
  BOTTOM w0.254: PU3.10 v1(138.69,52.62) ; PR87.1 136.23,55.31 PR80.2 137.05,54.71 v1(137.26,54.5)
CHG_LODRV_D: length 7.4
  TOP w0.635: v1(142.67,57.93) 142.67,57.85 142.06,57.24 v2(142.06,56.68) 142.06,54.4 v1(141.29,53.62)
  BOTTOM w0.254: v1(141.29,53.62) PU3.15
  BOTTOM w0.635: PR94.1 143.39,57.93 v1(142.67,57.93)
CHG_LODRV_D1: length 2.8
  BOTTOM w0.254: PR94.2 143.84,59.53 143.66,59.35 143.31,59.35 142.9,58.95 142.34,58.95 v2(142.09,58.69)
CHG_PHASE_S: length 17.1
  TOP w0.635: v1(142.8,49.73) 142.22,50.31 142.22,52.93 143.44,54.15 143.44,56.51 143.91,56.98 v2(143.91,58.97) 143.91,60.84 142.06,62.68 v1(142.06,63.72)
  BOTTOM w0.254: PU3.19 142.44,50.39 142.8,50.03 v1(142.8,49.73)
CHG_REGN_D: length 1
  TOP w0.102: v1(143.18,52.82) 143.61,52.82 v2(143.99,53.2)
CHG_SCL_A: length 5.6
  TOP w0.102: v1(135.18,52.27) 135.43,52.01 v2(135.89,52.01)
  BOTTOM w0.102: v1(135.18,52.27) 135.38,52.47 135.81,52.47 PR81.2 136.66,52.92 136.7,52.96 PR88.1 138.05,52.02 138.05,51.52 138.18,51.39 PU3.9
CHG_SDA_A: length 7.8
  TOP w0.102: v2(135.18,47.64) 134.88,47.95 134.88,49.7 135.08,49.9 v1(135.08,50.39)
  BOTTOM w0.102: PU3.8 137.59,50.89 137.41,51.08 PR82.2 ; v1(135.08,50.39) 135.31,50.61 136.32,50.61 PR82.2 ; PR82.2 136.79,51.08 PR89.1
CHG_SRN_A_R: length 34.1
  TOP w0.102: v2(135.13,70.35) 134.58,70.35 v1(134.33,70.1)
  IN3 w0.127: v1(134.33,70.1) 134.45,70.22 143.11,70.22 145.14,68.19 145.14,58.84 143.22,56.93 141.34,56.93 140.67,56.25 139.47,56.25 139.19,56.53 v1(139.19,57.42)
  BOTTOM w0.102: v1(139.19,57.42) 139.19,56.62 PC72.1 PC70.2 139.1,55.08 PR96.2
  BOTTOM w0.127: PJP5.1 134.15,70.45 134.33,70.28 v1(134.33,70.1)
CHG_SRP_A_R: length 33
  TOP w0.102: v1(132.88,70.08) 132.56,70.4 v2(132.56,70.76)
  TOP w0.127: v1(140.11,57.29) 140.41,57 PC71.1 140.8,56.99 PR95.2
  IN3 w0.127: v1(140.11,57.29) 140.17,57.23 143.09,57.23 144.86,59 144.86,68.04 142.98,69.92 134.81,69.92 134.52,69.63 133.34,69.63 132.89,70.08 v1(132.88,70.08)
  BOTTOM w0.102: 133.05,69.92 133.04,69.92 v1(132.88,70.08)
  BOTTOM w0.127: v1(140.11,57.29) 140.11,55.87 139.99,55.74 139.98,55.74 PC70.1 ; 133.05,69.92 PJP4.1
