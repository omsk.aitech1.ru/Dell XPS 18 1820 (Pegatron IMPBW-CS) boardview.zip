# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_SENSE: length 20.3
  BOTTOM w0.203: U1.E63 23.22,29.12 23.22,27.09 24,26.31 24,24.96 25.11,23.85 25.11,17.82 23.09,15.81 21.3,15.81 21.03,15.54 21.03,14.8 v2(20.37,14.14) 20.02,13.78 PR130.1
VCCSDIO_R: length 24.2
  TOP w0.102: v2(29.59,77.44) 29.59,77.31 v1(28.91,76.62)
  IN1 w0.254: v1(28.91,76.62) 28.91,74.89 28.34,74.32 28.34,70.54 28.53,70.35 28.53,67.43 28.73,67.23 28.73,62.96 29.41,62.27 v1(29.41,61.87)
  BOTTOM w0.254: PR46.2 28.12,79.98 28.3,80.15 PC39.1 28.68,80.13 28.68,79.8 29.08,79.39 29.52,79.39 29.75,79.16 29.75,77.47 v1(28.91,76.62) ; U1.T9 29.51,62.77 29.71,62.98 U1.U8
  BOTTOM w0.305: v1(29.41,61.87) 29.23,62.05 U1.T9
VDD_EN: length 43.2
  TOP w0.178: U6.14 160.09,27.12 159.51,27.7 159.19,27.7
  TOP w0.254: 159.19,27.7 158.88,28.02 158.88,28.9 R301.1 158.11,29.67 158.11,30.35 156.73,31.73 156.73,34.67 157.57,35.5 162.76,35.5 162.96,35.31 165.24,35.31 166.04,36.11 v2(167.64,36.11) 169.19,34.56 v1(170.05,34.56)
  IN2 w0.254: v1(186.01,30.7) 185.5,30.19 181.43,30.19 180.06,31.56 173.08,31.56 170.05,34.59 v1(170.05,34.56)
  BOTTOM w0.254: VU5.2 v1(186.01,30.7)
VDDEN: length 36.3
  TOP w0.254: v1(170.89,34.64) 170.23,33.98 168,33.98 167.13,34.84 v2(166.42,34.84) 162.84,34.84 162.56,35.12 157.69,35.12 157.09,34.52 157.09,32.03 158.6,30.52 R301.2
  IN2 w0.254: v1(170.89,34.64) 172.22,33.31 176.48,33.31 176.71,33.55 v1(179.91,33.55)
  BOTTOM w0.254: VU5.4 184.98,34.64 R297.1 R300.2 R304.1 181.5,33.43 R302.1 180.24,33.88 v1(179.91,33.55)
VSS_SENSE: length 19.7
  BOTTOM w0.089: 22.89,28.62 22.84,28.67 22.84,29.46 23.2,29.82 U1.E62
  BOTTOM w0.203: PR131.1 19.88,15.54 20.37,15.54 20.83,15.99 v2(20.83,16.14) 22.95,16.14 24.78,17.96 24.78,23.7 23.67,24.81 23.67,26.15 22.89,26.94 22.89,28.62
+1.05A_DCPSUS1: length 2.5
  TOP w0.457: v1(33.37,61.7) 33.37,62.16 33.5,62.29 PC30.1
  BOTTOM w0.254: U1.AD8 U1.AD10 33.52,61.85 v1(33.37,61.7)
+1.05A_DCPSUS2: length 2.4
  TOP w0.508: v2(34.77,60.57) 35.22,60.12 v1(35.67,60.12) 35.74,60.06 35.8,60 PC25.2
  BOTTOM w0.254: U1.AH13 35.99,60.44 v1(35.67,60.12)
+1.05A_VCCUSB3SUS: length 1.8
  TOP w0.457: v1(25.5,60.92) 26.22,60.19 PC23.1
  BOTTOM w0.254: U1.J13 25.73,60.54 25.5,60.77 v1(25.5,60.92)
+1P5V: length 482.8
  TOP w0.508: R316.1 170.47,64.94 v1(170.11,64.94) ; v1(120.32,88.08) 120.98,88.08 121.87,87.19 121.87,87.06 v1(122.18,86.76)
  IN1 w0.254: v1(25.54,59.97) 26.06,59.44 26.06,57.33 27.02,56.38 31.27,56.38 32.95,54.7 33.57,54.7 34.1,54.17 34.1,52.76 33.99,52.65 33.99,51.68 34.42,51.25 v1(34.44,51.25)
  IN1 w0.508: v1(170.11,64.94) 171.19,64.94 171.72,64.41 171.72,63.89 170.35,62.53 167.82,62.53 166.05,60.76 164.06,60.76 163.25,59.96 163.25,59.64 161.44,57.83 157.76,57.83 154.46,54.53 154.46,50.61 149.56,45.71 146.43,45.71 144.96,44.24 142.8,44.24 142.37,44.67 139.68,44.67 138.71,43.71 138.71,41.58 138.02,40.89 136.25,40.89 134.04,38.68 131.01,38.68 130.48,39.21 125.17,39.21 124.64,38.68 119,38.68 117.53,40.15 v1(115.06,40.15) ; v1(86.25,84.57) 88.95,84.57 90.17,83.35 93.14,83.35 94.47,84.68 95.73,84.68 96.93,83.48 98.58,83.48 100.32,85.23 105.7,85.23 105.92,85.01 111.07,85.01 111.08,85.01 111.1,85.01 111.26,84.85 114.29,84.85 115.12,84.02 117.48,84.02 118.34,84.88 118.55,84.88 119.07,84.88 119.07,84.88 121.69,84.88 122.18,85.36 v1(122.18,86.76)
  IN2 w0.254: v1(86.25,84.57) 85.96,84.87 85.96,85.89 85.5,86.35 81.1,86.35 80,87.46 74.97,87.46 73.79,86.28 67.22,86.28 66.41,85.46 65.43,85.46 64.94,84.97 61.5,84.97 61.2,84.66 56.09,84.66 55.85,84.91 52.07,84.91 51.56,85.42 47.01,85.42 46.36,84.77 41.04,84.77 40.39,85.43 38.36,85.43 37.9,85.89 37.51,85.89 35.96,84.35 31.4,84.35 31.25,84.2 25.47,84.2 23.12,81.85 22,81.85 19.13,78.99 18.07,78.99 15.48,76.4 15.48,73.99 15.98,73.49 15.98,70.89 v1(15.05,69.96)
  IN2 w0.508: v1(92.15,33.27) 91.26,32.38 91.26,22.98 88.8,20.52 88.8,19.14 85.07,15.41 78.49,15.41 77.4,14.32 v1(72.21,14.32) ; v1(44.73,22.34) 44.73,23.54 42.8,25.47 38.58,25.47 37.87,26.18 37.87,28.77 35.26,31.39 35.26,33.09 34.44,33.9 v1(34.44,51.25) ; v1(170.11,64.94) 170.87,65.7 170.87,66.13 172.44,67.71 176.56,67.71 179.27,70.42 179.27,74.27 179.26,74.28 179.26,75.93 178.47,76.71 178.47,77.59 179.19,78.31 180.14,78.31 181.23,79.4 181.23,88.43 179.41,90.25 156.02,90.25 155.53,89.76 130.01,89.76 127.89,87.64 123.06,87.64 v1(122.18,86.76)
  IN3 w0.508: v1(92.15,33.27) 96.06,37.18 96.06,38.02 99.21,41.17 103.81,41.17 104.52,40.45 106.71,40.45 107.77,39.39 114.3,39.39 v1(115.06,40.15)
  BOTTOM w0.254: U1.J15 25.54,59.68 25.54,59.96 v1(25.54,59.97) ; v1(86.25,84.57) 86.25,87.93 85.01,89.17 83.52,89.17 83.25,88.9 83.25,88.08 82.91,87.74 82.23,87.74 81.87,87.37 81.35,87.37 80.36,86.38 77.62,86.38 75.6,84.35 72.74,84.35 71.97,83.58 69.75,83.58 68.86,84.47 67.77,84.47 PR56.2 ; v1(15.05,69.96) 14.98,69.89 PR57.2
  BOTTOM w0.457: 120.32,88.17 120.32,89.17 119.84,89.65 PR55.2 ; PC176.1 46.69,14.51 46.39,14.22 PR189.1
  BOTTOM w0.508: PC175.1 49.01,14.09 48.57,14.09 48.14,14.51 PC176.1 47.38,13.32 PU9.5 ; PC175.1 50.35,14.54 51.94,12.95 v2(53.37,12.95) 54.02,13.6 60.29,13.6 61.27,12.63 64.81,12.63 66.85,14.67 71.86,14.67 v1(72.21,14.32) ; PC175.1 49.21,14.54 48.29,15.46 48.29,16.4 46.25,18.43 46.25,20.82 v1(44.73,22.34) ; 120.32,88.17 v1(120.32,88.08)
+1P05V: length 353.9
  TOP w0.254: v1(20.85,74.26) 20.12,73.52 20.12,72.37 PR35.2
  TOP w0.457: PC37.1 25.2,62.15 v1(25.45,61.9) ; v1(29.16,55.75) 29.01,55.89 PC36.1
  TOP w0.508: PC20.1 34.24,58.87 34.61,58.5 v1(35.68,58.5) ; SR18.1 19.15,22.69 v1(18.31,22.69) ; PC19.1 25.15,59.34 v1(25.41,59.08) ; v1(53.42,58.97) 53.42,59.63 54.9,61.11 54.9,64.14 55.87,65.1 55.87,68.16 56.71,69 56.71,70.57 57.72,71.59 57.72,72.17 57.23,72.66 v1(56.34,72.66) ; L2.1 145.79,15.63 145.21,15.63 v1(144.89,15.31) ; HR34.1 63.83,17.9 63.4,18.33 v1(63.4,19.35) ; v2(121.52,17.09) 121.52,16.73 v1(121.85,16.4) ; GR5.1 v1(82.7,14.31) ; R433.1 170.93,61.94 v1(170.74,61.94)
  IN1 w0.508: v1(48.31,81.04) 48.31,80.28 46.9,78.87 46.9,76.92 45.98,75.99 43.92,75.99 42.76,74.84 42.76,72.5 42.44,72.18 42.44,70.43 42.06,70.05 42.06,68.44 41.45,67.84 40.26,67.84 39.49,68.61 39.03,68.61 38.58,69.05 37.47,69.05 36.25,67.84 35.77,67.84 34.71,66.78 34.71,62.75 34.06,62.09 v1(34.06,61.8) ; v1(111.02,48.91) 111.08,48.91 112.02,47.98 112.02,45.03 113.36,43.68 113.36,40.2 v1(119.94,33.62) 122.99,36.67 133.3,36.67 136.31,39.68 140.75,39.68 142.42,41.35 142.42,42.41 142.9,42.89 148.15,42.89 156.82,51.56 156.82,52.74 157.85,53.76 159.15,53.76 165.27,59.89 166.3,59.89 168.2,61.79 170.59,61.79 v1(170.74,61.94) ; v1(18.31,22.69) 22.43,18.57 25.22,18.57 25.44,18.79 28.22,18.79 28.44,18.57 30.47,18.57 v1(31.35,17.7) v1(33.17,17.7) 34.28,18.8 34.89,18.8 35.26,18.44 35.26,18.19 35.27,18.18 v1(35.27,17.95)
  IN2 w0.254: v1(20.85,74.26) 20.77,74.35 20.77,75.74 23.59,78.57 23.59,79.87 24.2,80.48 24.59,80.48 26.93,82.82 31.82,82.82 31.97,82.98 39.27,82.98 39.68,83.39 41.23,83.39 42.31,82.31 43.49,82.31 44.57,83.4 48.26,83.4 48.46,83.61 v1(48.46,83.9)
  IN2 w0.508: v1(115.29,62.4) 116.18,61.51 116.18,58.23 115.98,58.03 114.07,58.03 113.42,57.37 111.81,57.37 110.07,55.64 110.07,49.42 110.58,48.91 v1(111.02,48.91) ; v1(119.94,33.62) 119.75,33.43 119.75,23.46 121.85,21.37 v1(121.85,16.4) ; v1(12.24,34.08) 12.73,33.6 14.1,33.6 16.82,30.88 16.82,27.73 18.92,25.62 18.92,23.13 18.53,22.74 18.37,22.74 v1(18.31,22.69)
  IN3 w0.508: v3(110.31,11.02) 110.31,12.29 114.71,16.68 121.16,16.68 121.44,16.4 v1(121.85,16.4) 127.84,16.4 130.78,19.33 133.65,19.33 135.87,17.11 142.69,17.11 144.49,15.31 v1(144.89,15.31)
  BOTTOM w0.254: U1.H11 25.08,61.54 v1(25.45,61.9) 25.73,61.61 U1.J11 ; U1.AG8 35.23,63.22 35,62.99 35,62.86 35,62.85 35,62.83 U1.AF9 U1.AE9 33.99,61.87 v1(34.06,61.8) ; v1(35.27,17.95) 35.27,18.42 35.63,18.78 35.63,20.82 35.23,21.21 35.23,21.97 35.37,22.11 35.37,23.16 35.08,23.45 35.08,23.45 GR31.1 ; U1.AG17 35.3,58.13 v1(35.68,58.5) 35.65,58.53 35.36,58.82 35.3,58.87 U1.AG16 ; U1.H15 25.16,59.41 25.16,59.33 v1(25.41,59.08) 25.73,58.76 U1.J17 ; U1.AE8 34.21,63.48 v1(33.98,63.48) ; v1(20.85,74.26) 20.75,74.36 PL4.1 ; U1.AF22 35.06,55.41 35.06,55.63 v1(35.12,55.69) ; U1.R21 28.79,56.12 v1(29.16,55.75) 29.53,56.12 U1.T21 ; PC29.1 49.2,82.73 PR41.1 48.95,82.97 48.15,82.97 PC28.1 48.15,82.49 48.36,82.49 48.6,82.25 48.6,81.33 v1(48.31,81.04) 48.69,80.66 PR40.1
  BOTTOM w0.457: v1(115.29,62.4) 115.29,63.58 115.7,63.99 R230.1
  BOTTOM w0.508: v1(33.17,17.7) 33.73,18.25 GR29.1 GR28.1 ; HR32.1 52.53,59.86 v1(53.42,58.97) ; v1(48.46,83.9) 49.65,83.9 PC29.1 51.85,81.7 54.23,81.7 54.79,81.14 ; 54.81,79.88 54.46,79.54 54.46,77.18 PC21.1 53.49,76.21 53.49,74.02 PL3.1 52.86,72.74 56.26,72.74 v1(56.34,72.66) ; CKR2.2 11.77,38.35 PC40.1 11.5,37.8 11.66,37.63 ; v1(31.35,17.7) GR30.1 ; PC168.1 111.71,4.84 110.49,6.06
  BOTTOM w0.762: HR33.1 11.33,33.01 11.48,33.16 11.48,34.51
  vias: v3(108.28,10) v3(108.66,9.11) v3(108.92,11.02) v3(109.55,10.13) v3(111.3,11.04)
+1P05V_BOOT1_D: length 1.1
  TOP w0.508: v2(115.72,13.15) 115.72,13.02 v1(116.41,12.34)
+1P05V_BOOT_D: length 0.8
  TOP w0.508: v2(118.24,13.15) 118.24,12.69 v1(118.47,12.46)
+1P05V_EDP: length 21.5
  TOP w0.178: C59.1 161.36,29.13 161.65,28.85 161.65,27.98 162.09,27.54 U6.9 ; U6.59 167.06,23.92 167.36,23.61 167.64,23.61 168.12,23.13 C55.1 ; 157.37,19.08 157.71,19.42 158.32,19.42 158.44,19.55 U6.32 ; U6.46 164.49,18.41 164.62,18.28 164.62,17.49 164.48,17.36 C54.1 ; U6.1 165.68,26.77 166.75,27.84 C56.1
  TOP w0.432: C9206.1 155.38,18.66 C58.1 156.54,19.01 C57.1 156.59,18.41 156.85,18.15 C9207.1 157.37,19.08 ; v1(164.12,18) 164.07,17.94 C54.1 ; C55.1 167.44,22.89 v1(167.46,22.89) ; v1(166.82,27.17) C56.1 ; v1(161.14,28.36) 161.14,28.97 C59.1
  TOP w0.508: L2.2 148.46,16.31 148.56,16.41 148.93,16.41 v2(149.1,16.58) 149.1,17.18 v1(148.97,17.31) ; C9206.1 154.84,18.1 v1(154.64,18.31)
+1P05V_EN_A: length 8.4
  TOP w0.203: v1(120.37,8.91) 120.37,9.42 v2(118.39,11.4)
  TOP w0.254: PR180.2 120.26,13.54 120.09,13.71 PC170.1 119.48,13.06 119.34,12.92 PR182.2 118.39,11.48 v2(118.39,11.4)
  BOTTOM w0.203: PU8.13 120,8.44 120.37,8.81 v1(120.37,8.91)
+1P05V_FB1_A: length 21.1
  TOP w0.254: v1(106.71,11.6) 107.52,11.6 110.61,14.69 113.2,14.69 114.12,13.76 115.83,13.76 116.28,14.22 116.28,17.24 v2(116.77,17.72) 119.04,17.72 119.34,17.42 PR185.1 120.16,16.98 PC172.1
  BOTTOM w0.152: v1(106.71,11.6) 106.61,11.5 PJP16.2
+1P5V_FB_A: length 4.3
  BOTTOM w0.254: PU9.4 45.32,12.84 45.12,13.03 PR189.2 45.12,14.72 45.12,14.73 PR191.1 45.12,16.06 v2(45.39,16.32)
+1P05V_FB_A: length 11.5
  TOP w0.254: v1(119.74,8.88) 119.74,9.11 117.81,11.04 117.81,11.79 PR181.2 v1(117.2,13.05) 117.2,13.52 PR186.1 117.51,14.43 116.97,14.98 v2(116.97,15.77) 116.97,16.37 117.57,16.98 PR185.2
+1P05V_PHASE_D: length 2.2
  TOP w0.508: v1(117.6,7.43) v2(118.59,7.43)
  BOTTOM w0.508: 115.99,5.69 PR179.2 116.59,6.29
+1P05V_PWRGD: length 152.1
  TOP w0.254: R60468.1 140.77,82.14 141.96,82.14 142.32,81.78 142.32,80.43 142.7,80.05 142.7,78.68 v2(141.8,77.79) 141.43,77.41 v1(141.43,76.27) ; v1(123.52,9.49) 123.52,1.77 v1(123.38,1.63)
  IN1 w0.254: v1(123.52,9.49) 121.24,11.78 108.28,11.78 102.69,6.19 v1(102.69,5.81)
  IN2 w0.254: v1(123.52,9.49) 123.55,9.52 125.71,9.52 130.07,13.89 131.7,13.89 134.85,17.04 139.35,17.04 144.4,22.09 144.4,23.72 149.05,28.36 149.05,42.74 151.74,45.43 151.74,62.05 146.41,67.39 146.41,74.41 145.25,75.57 142.49,75.57 141.79,76.27 v1(141.43,76.27)
  BOTTOM w0.178: 120.17,4.39 120,4.55 PU8.4
  BOTTOM w0.254: HU4.2 99.72,5.38 100.31,5.96 100.97,5.96 101.25,5.68 101.25,4.36 100.69,3.8 HR46.2 100.64,3.34 101.6,3.34 102.69,4.43 v1(102.69,5.81) ; 120.17,4.39 120.32,4.39 120.47,4.23 120.47,4.03 120.85,3.65 121.49,3.65 121.72,3.42 PR184.2 122.11,3.92 122.43,4.23 123.19,4.23 123.52,3.9 123.52,1.77 v1(123.38,1.63)
+1P05V_RC_A: length 9.1
  TOP w0.254: PR181.1 117.2,10.61 116.56,9.97 v2(116.56,8.78) 116.56,6.6 v1(117.53,5.63)
  BOTTOM w0.254: PC168.2 116.18,4.84 116.22,4.81 PR179.1 117.03,4.81 117.53,5.3 v1(117.53,5.63)
+1P05V_VDD_C: length 2.7
  BOTTOM w0.508: v2(122.43,10.63) 122.13,10.94 119.87,10.94
+1P05V_VIN: length 2
  BOTTOM w0.508: v2(127.08,8.93) 126.15,8.01 125.5,8.01
+1P05V_VOUT_A: length 11.5
  BOTTOM w0.152: 109.75,5.07 109.55,5.07 109.43,5.19 PJP15.2
  BOTTOM w0.178: 118.29,4.59 118.67,4.59 118.8,4.72 PU8.7
  BOTTOM w0.254: 109.75,5.07 109.91,4.92 109.91,4.41 v2(110.26,4.05) 110.79,3.52 PC171.1 117.68,3.84 117.68,3.98 118.29,4.59
+1P35V_DUAL: length 360
  TOP w0.203: U3.G7 76.78,38.79 77.18,39.18 77.18,39.74 U3.H9 ; 81.18,28.2 82.36,28.2 82.37,28.22 82.55,28.22 82.94,28.61 U2.R9 ; U3.K2 78.96,34.54 78.57,34.15 v1(77.98,34.15)
  TOP w0.216: U5.K2 78.78,66.29 78.22,66.29 78.21,66.28 v1(77.98,66.28) ; v1(78.78,54.75) 78.55,54.75 78.55,54.75 78.22,54.75 77.82,54.35 U4.H2
  TOP w0.254: v1(72.39,53.13) 72.37,53.15 72.26,53.15 71.98,53.43 U4.A1 U4.B2 ; U5.K8 79.58,70.29 v1(79.58,70.29) ; v1(79.58,59.55) 79.58,59.55 U4.K8 ; U2.R1 83.18,22.02 83.19,22.01 82.78,21.6 v1(82.6,21.6) ; v1(171.1,64.15) 170.26,63.31 v2(170.26,62.93) ; v1(78.79,23.4) U2.K2 ; v1(77.98,34.15) 77.59,34.54 U3.H2 ; U3.D2 74.29,34.45 74.08,34.45 73.58,33.95 U3.C1 ; v1(78.78,27.41) 78.79,27.42 78.79,27.42 U2.K8 ; U4.R1 83.26,53.48 83.26,52.92 82.88,52.54 v1(82.88,52.49) ; U5.N1 81.74,64.93 v1(81.74,63.97) ; U4.R9 83.28,59.95 83.6,60.27 v1(83.6,60.42)
  TOP w0.305: v1(82.78,40.68) 83.18,40.28 U3.R9 ; U2.N9 81.18,28.2 v1(81.18,28.2) ; U2.G7 76.43,26.66 v1(76.43,26.56) ; U4.C1 v1(73.98,53.95) U4.D2 ; v1(77.18,71.09) 77.58,71.49 U5.H9 ; U2.N1 81.58,22.01 v1(81.18,21.6) ; v1(78.78,54.75) 79.17,54.35 U4.K2 ; v1(73.16,53.14) 73.7,52.61 75.04,52.61 U4.F1 ; v1(74.83,71.98) 74.83,71.83 75.17,71.49 U5.E9 ; U2.C1 73.84,21.95 v1(73.84,21.66) ; U3.N9 81.56,40.14 81.18,40.52 v1(81.18,40.54) ; U4.N1 81.58,53.55 v1(81.18,53.15) 81.26,53.15 81.74,52.67 ; U4.D9 U4.C9 73.58,60.45 v1(73.23,60.8) ; v1(70.54,24.76) 70.2,24.42 C36.1 ; U2.H9 77.58,28.61 v1(77.18,28.21) ; C11.1 71.73,64.84 U5.A1 U5.B2 ; U3.H9 77.58,40.28 78.08,40.78 v1(78.08,40.8) ; v1(83.59,71.09) 83.19,71.49 U5.R9 ; U3.B2 U3.A1 71.98,33.74 71.38,33.14 v1(71.32,33.14) ; U5.D2 U5.C1 73.3,64.81 v1(73.3,64.59) ; HU1.5 66.04,67.71 66.47,67.28 67.06,67.28 HC1.1 ; U2.D9 74.38,28.68 v1(73.99,29.07) 73.58,28.66 U2.C9 ; U3.R1 83.18,33.42 83.21,33.39 83.21,32.93 82.91,32.62 82.83,32.62 v1(82.71,32.5) 82.57,32.64 82.48,32.64 82.12,33 82.12,33.2 U3.N1 ; v1(76.48,57.69) 76.48,57.7 76.49,57.69 76.51,57.7 76.51,57.71 76.53,57.74 76.53,58.09 76.78,58.34 U4.G7 ; U2.B2 U2.A1 71.98,22.21 v1(71.58,21.81) ; U3.F1 75.83,33.59 75.83,33.47 75.72,33.36 75.72,33.17 v1(75.71,33.16) ; U5.N9 81.59,71.49 v1(81.99,71.09) ; v1(74.25,40.91) 73.58,40.25 U3.C9 ; v1(74.8,29.1) 75.18,28.72 U2.E9 ; v1(71.4,70.81) 71.52,70.69 U5.A8 ; v1(77.19,22.61) 77.19,22.62 U2.H2 ; U5.F1 v1(75.58,65.49) ; U5.C9 v1(73.98,71.09) 74.38,71.49 U5.D9 ; v1(71.45,59.63) 71.74,59.34 71.8,59.34 U4.A8 ; U5.R1 83.17,65.09 v1(82.78,65.48) ; U5.G7 76.05,69.16 v3(76.05,69.16) ; U2.D2 74.38,23.01 74.77,23.4 74.77,23.41 v1(74.77,23.41) ; U3.E9 75.18,40.48 v1(74.91,40.76) 74.38,40.23 U3.D9 ; v1(77.98,59.55) U4.H9 ; U2.F1 75.98,21.9 75.74,21.67 v1(75.74,21.43) ; U2.A8 71.02,27.81 70.32,28.5 C35.1 D3CE25.1 68.86,29.05 69.24,29.43 v1(69.9,29.43) ; U4.N9 81.92,60.29 v1(81.92,60.41) ; v1(74.82,61.08) 74.82,60.32 U4.E9 ; U3.C1 73.58,33.74 v1(72.95,33.11) ; v1(77.98,66.28) 77.59,65.89 U5.H2 ; U3.A8 71.88,39.34 v1(71.45,39.77) ; v1(79.58,38.94) 79.18,39.34 U3.K8
  TOP w0.457: R29.2 81.85,51.57 81.74,51.68 81.74,52.67
  TOP w0.508: v1(181.05,69.31) 180.43,68.69 R322.1 ; v1(88.18,36.95) 87.68,37.45 C4.1 ; HC1.1 68.58,67.64 C39.1 68.99,67.53 69.72,68.27 v1(69.72,68.62) ; v1(69.08,54.04) 68.75,53.71 D3CE26.1 ; v1(87.61,21.12) 86.98,21.75 R38.1 ; v1(53.9,17.9) 53.9,17.9 ; 53.9,17.9 53.3,17.3 R56.2 52.15,17.3 R41.2 ; 53.9,17.9 53.9,17.96 53.14,18.72 R57.2 ; D3CE21.1 68.75,24.42 C36.1 ; v3(111.96,59.63) 112.19,59.4 112.19,59.17 PC156.1 ; R40.2 v1(83.33,19.74) ; v1(53.87,55.9) 53.85,55.92 C1175.1 ; v1(84.51,20.77) 84.74,20.54 D3CE20.1 ; 88.7,61.51 88.7,60.93 88.36,60.58 D3CE24.1 C32.1 ; v1(71.07,62.93) 70.89,62.76 C14.1 C41.1 C11.1 ; C31.1 68.92,48.32 v1(69.24,48) ; C13.1 70.29,41.82 v1(70.5,41.61) ; C34.1 69.93,32.05 v1(69.57,32.4) 69,32.97 C19.1 ; D3CE8.1 69.72,51.31 v1(69.72,51.88) ; v1(69.27,59.71) 68.9,59.34 C15.1 68.35,59 68.04,59.31 C30.1 68.04,63.76 67.34,64.45 HQ2.3 ; D3CE23.1 88.27,30.66 v1(88.36,30.57) ; v1(71.32,33.14) 71.25,33.14 70.45,33.93 C33.1 ; C16.1 69.89,21.32 v1(70.03,21.45) ; v1(85.19,18.61) 86.06,19.47 C17.1 ; D3CE7.1 68.34,56.62 68.67,56.29 v1(69.09,56.29) ; C1176.1 58.83,56.48 58.57,56.74 C1174.1 57.99,55.86 58.01,55.84 58.02,55.84 v1(58.02,55.86)
  IN1 w0.508: v1(171.1,64.15) 170.5,63.56 169.51,63.56 169.28,63.78 167.86,63.78 165.44,61.37 163.8,61.37 163.26,60.82 160.78,60.82 159.74,59.78 158.07,59.78 157.95,59.9 154.96,59.9 151.72,56.65 151.72,52.25 148.17,48.7 147.7,48.7 146.36,47.36 146.36,46.65 145.72,46.02 144.4,46.02 143,47.41 139.73,47.41 137.85,45.53 137.85,44.26 137.11,43.53 136.42,43.53 135.23,42.33 135.23,40.86 133.96,39.59 131.27,39.59 129.64,41.22 117.12,41.22 113.54,44.8 113.54,47.16 113.06,47.64 113.06,54.2 111.28,55.97 111.28,56.91 111.96,57.6 v3(111.96,59.63) ; v1(74.82,61.08) 74.6,60.86 74.6,60.34 74.16,59.9 74.16,59.3 75.45,58.01 76.16,58.01 v1(76.48,57.69) ; v1(81.18,40.54) 81.08,40.54 80.48,41.13 80.48,48.57 77.84,51.22 77.84,53.89 78.7,54.75 v1(78.78,54.75)
  IN2 w0.508: v1(79.58,59.55) 79.57,59.55 v1(77.98,59.55) 77.8,59.55 76.99,60.37 76.99,60.42 76.48,60.93 74.97,60.93 v1(74.82,61.08) ; 76.94,20.57 76.94,18.25 74.21,15.52 67.37,15.52 64.38,18.52 54.28,18.52 53.9,18.14 v1(53.9,17.9) ; v1(181.05,69.31) 179.02,69.31 176.81,67.1 172.7,67.1 171.76,66.16 171.76,64.81 v1(171.1,64.15)
  IN2 w0.762: v3(104.12,62.81) 104.8,62.81 105.13,63.14 106.68,63.14 107.39,63.85 111.41,63.85 112.17,63.09 112.17,60.95 111.96,60.75 v3(111.96,59.63)
  IN3 w0.508: v1(73.23,60.8) 74.54,60.8 v1(74.82,61.08)
  BOTTOM w0.127: C1179.1 46.25,40.28 45.95,40.58 45.95,41.07 45.56,41.45 45.1,41.45 44.41,40.77 43.92,40.77 43.81,40.66 U1.AY44
  BOTTOM w0.254: v1(38.43,47.61) 38.43,47.76 38.73,48.06 U1.AN33 ; v1(39.06,42.3) 39.38,41.97 U1.AP43 ; C1179.1 46.52,40.82 46.52,40.92 46.43,41.01 46.43,42.08 44.15,44.37 43.63,44.37 43.14,43.88 U1.AY40 ; C1181.1 45.18,38.94 44.85,38.61 44.54,38.61 44.29,38.36 43.99,38.36 U1.AY50 ; C1180.1 45.44,45.31 45.44,46.57 45.16,46.86 44.76,46.86 44.76,46.85 44.55,46.85 44.55,46.86 44.15,46.86 44.15,46.85 43.94,46.85 43.94,46.86 43.54,46.86 43.54,46.85 43.39,46.85 43.32,46.92 43.18,46.92 U1.AY35 ; U1.AR48 40.03,38.95 40.03,39.33 v1(39.82,39.53)
  BOTTOM w0.305: DIMM1.87 60.5,45.05 60.72,45.27 61.15,45.27 61.45,44.96 61.45,44.89 v1(61.59,44.74) ; U1.AH26 35.59,52.8 35.26,52.8 35.1,52.95 35.1,52.99 v1(35.08,53.01) ; DIMM1.81 58.35,43.25 58.1,43 v1(57.74,43) ; DIMM1.75 60.76,41.45 v1(60.92,41.29) ; U1.AJ37 35.49,45.43 v1(35.3,45.23) ; DIMM1.93 60.95,46.85 61.11,46.69 61.13,46.69 61.44,46.38 61.44,46.36 61.64,46.17 v1(61.56,46.17) ; DIMM1.117 58.05,54.05 58.04,54.04 57.99,54.04 v1(57.94,54.09) ; v1(35.26,49.33) U1.AJ31 ; 58.14,55.85 DIMM1.123 ; U1.AJ33 36.13,48.03 v1(35.27,48.03)
  BOTTOM w0.356: 69.5,45.36 69.49,45.35 DIMM1.88 ; 57.98,52.25 DIMM1.111 ; 69.27,50.77 69.25,50.75 DIMM1.106 ; 69.42,41.75 69.42,41.75 DIMM1.76 ; 69.27,56.15 DIMM1.124 ; DIMM1.94 69.38,47.15 69.39,47.13 ; 69.34,43.53 69.32,43.55 DIMM1.82 ; DIMM1.100 69.25,48.95 69.27,48.96 ; 69.24,52.57 69.22,52.55 DIMM1.112 ; 57.87,48.65 DIMM1.99 ; DIMM1.118 69.16,54.35 ; DIMM1.105 58.46,50.45 58.11,50.1 v1(58.11,49.47)
  BOTTOM w0.508: v1(46.38,34.46) 46.76,34.83 C1178.1 ; v1(47.68,44.25) 47.68,44.24 47.24,43.8 C1180.1 ; v1(47.61,38.94) 47.52,38.94 ; 47.52,38.94 C1181.1 ; 47.52,38.94 47.6,39.02 47.6,39.74 C1179.1 ; C1182.1 46.95,36.13 47.2,35.87 v1(47.61,35.87) ; D3CE4.1 54.11,56.14 v1(53.87,55.9) ; D3CE22.1 57.23,41.99 ; D3CE27.1 57.24,45.67
  vias: v1(55.08,49.7) v1(55.6,49.34) v1(56.54,54.09) v1(57.96,51.91) v1(69.09,51.88) v1(70.16,70.31) v1(70.16,69.68) v1(70.42,71.54) v1(70.42,70.91) v1(70.79,69.73) v1(71.31,41.61) v1(85.33,24.72) v1(85.47,27.7) v1(86.36,69.99) v1(86.34,69.34) v1(86.36,68.04) v1(86.52,66.1) v1(89.45,62.45) v3(86.4,65.35) v3(87.3,65.35) v3(93.85,60.44) v3(93.87,55.65) v3(93.88,59.48) v3(93.88,58.54) v3(93.89,57.58) v3(93.88,56.62) v3(93.88,54.7)
+1P35V_DUAL_BOOT_C:
  vias: v2(111.18,59.08)
+1P35V_DUAL_BST_C:
  vias: v2(109.27,56.06)
+1P35V_DUAL_CS_A: length 5.1
  TOP w0.203: PU7.13 108.56,61.81 107.94,61.19 107.94,60.95 PR175.1
  TOP w0.254: v2(107.16,58.49) 106.94,58.72 106.94,60.06 107.46,60.59 PR175.1
+1P35V_DUAL_FB1_A: length 4.9
  TOP w0.203: PR174.1 114.6,64.43 PR173.1 113.74,64.43 113.62,64.31 PC154.2 112.75,64.31 112.63,64.43 v2(112.17,64.43) 111.94,64.43 111.62,64.11 PU7.6
+1P35V_DUAL_FB_A: length 32.4
  TOP w0.203: PR173.2 113.69,63.54 113.62,63.47 PC154.1 112.78,63.03 112.78,62.91 112.48,62.61 PU7.5
  TOP w0.254: v1(97.79,60.67) 100.15,63.03 100.79,63.03 104.95,67.2 108,67.2 108.61,67.81 109.23,67.81 109.42,68 110.03,68 110.24,67.8 113.09,67.8 114.06,68.76 114.58,68.76 115.81,67.53 116.13,67.53 v2(116.89,66.77) 116.89,64.3 116.5,63.91 PC155.1 115.48,63.42 114.76,63.42 114.63,63.54 PR173.2
  BOTTOM w0.152: v1(97.79,60.67) 97.79,60.62 97.65,60.48 PJP14.2
+1P35V_DUAL_HG_D: length 22.7
  TOP w0.203: v1(110.27,59.14) 110.42,59.29 PU7.17
  IN3 w0.635: v1(110.27,59.14) 110.27,58.11 109.55,57.4 109.55,46.04 108.17,44.66 v1(104.66,44.66)
  BOTTOM w0.508: v1(110.27,59.14) 110.27,59.74 v2(110.62,60.09)
  BOTTOM w0.635: PR166.1 v1(104.66,44.66)
+1P35V_DUAL_HG_R_D:
  vias: v2(105.37,45.43)
+1P35V_DUAL_LG_D: length 5.2
  TOP w0.203: v1(109.04,60.47) 109.04,60.87 109.19,61.01 PU7.15
  BOTTOM w0.635: PR169.1 109.49,57.25 v2(108.71,58.03) 109.04,58.36 v1(109.04,60.47)
+1P35V_DUAL_LG_R_D: length 2.1
  BOTTOM w0.508: PR169.2 109.72,54.82 v2(111.02,56.13)
+1P35V_DUAL_PHASE_D: length 5.2
  TOP w0.635: v1(106.99,54.32) 106.98,54.32 106.98,55.34 v2(107.01,55.36) 107.01,56.76 108.69,58.43 PC148.1
+1P35V_DUAL_PWRGD: length 53.9
  TOP w0.254: R60467.1 140.88,79.41 140.88,76.03 v2(141.68,75.23) 142.09,75.23 142.98,74.34 v1(142.98,73.97)
  TOP w0.508: v1(104.47,63.87) 104.47,64.13 104.93,64.58 106.39,64.58 PR171.2
  IN2 w0.254: v1(104.47,63.87) 104.47,63.89 106.85,66.26 114.58,66.26 116.31,67.99 118.56,67.99 119.58,69.01 119.58,70.01 121.07,71.49 122.66,71.49 123.04,71.87 123.04,72.22 124.22,73.4 142.67,73.4 142.98,73.7 v1(142.98,73.97)
+1P35V_DUAL_S3_A: length 6.3
  TOP w0.203: v2(113.65,66.77) 113.86,66.57 PR162.2 113.39,65.65 113.31,65.73 PR163.2 111.74,65.73 PC149.2 110.97,64.96 110.97,64 111.22,63.75 PU7.7
+1P35V_DUAL_S5_A: length 3.6
  TOP w0.203: PR168.2 PC151.1 110.4,65.3 v2(110.4,64.46) 110.4,64.11 110.82,63.7 PU7.8
+1P35V_DUAL_SN_C: length 1.8
  TOP w0.254: v2(107.57,50.13) v1(106.73,50.13)
  BOTTOM w0.508: PR167.2 v1(106.73,50.13)
+1P35V_DUAL_TON_A: length 3.9
  TOP w0.203: PU7.9 110.42,63.59 110.06,63.95 109.09,63.95 v2(108.66,64.38) 108.86,64.58 PR165.2
+1P35V_DUAL_VIN: length 22.2
  TOP w0.508: PR165.1 v1(108.86,67.31) 109.46,67.31 109.58,67.43 v2(109.75,67.43)
  IN3 w0.635: v1(108.86,67.31) 108.86,67.3 107.36,65.8 107.36,55.57 107.67,55.26 107.67,48.81 107.35,48.49 v1(107.35,47.72)
+3P3V: length 575.1
  TOP w0.254: v1(31.88,75.83) 32.19,75.52 SR13.1 ; R164.1 132.8,31.86 133.3,32.35 v1(133.3,33.3) ; U16.1 162.63,81.58 163.37,80.84 v1(163.37,80.66) ; v1(106.07,80.23) 106.07,80.81 106.25,80.99 R173.1 ; R148.2 C9220.1 6.71,80.38 v1(6.71,80.07) ; v1(104.29,69.91) 104.29,69.92 103.75,70.46 103.75,71.1 104.38,71.73 104.38,72.39 104.05,72.72 104.05,74.01 SR29.1 ; v1(24.72,75.29) 24.72,75.18 24.18,74.65 SR88.1 23.54,74.65 23.52,74.66 SR16.1 ; v1(158.57,80.52) 158.59,80.53 U17.1 ; 178.77,49.55 178.51,49.81 U21.6 ; RN4.1 26.22,72.5 25.97,72.75 ; U16.7 165.55,83.18 v1(165.6,83.22) 165.6,83.38 165.3,83.68 U16.8 ; CON5.3 88.46,77.43 87.67,78.22 v1(87.43,78.22) ; v1(121.03,12.67) 121.03,12.59 120.88,12.44 PR182.1 120.18,10.49 v2(120.42,10.25) 120.88,9.8 120.88,3.18 v1(122.44,1.62) ; 20.75,75.71 20.22,75.18 19.97,75.18 19.35,74.55 SR90.1 19.42,74.32 20.05,74.32 20.06,74.31 v1(20.06,74.32) ; 20.75,75.71 21.29,76.24 21.29,77.08 21.59,77.38 R416.1 ; 20.75,75.71 21.11,75.35 21.11,74.77 21.74,74.13 22.2,74.13 22.4,73.93 22.4,73.27 21.91,72.77 21.91,72.62 SR87.1 ; v1(88.29,78.66) 89.46,77.49 CON5.1 ; R79.2 29.57,73.36 v1(29.94,73.73) ; R378.1 R381.1 R380.1 R379.1 ; v1(69.09,69.26) 68.98,69.14 65.88,69.14 65.83,69.19 64.94,69.19 64.77,69.03 64.35,69.03 64.19,69.19 63.47,69.19 63.18,68.9 HR11.1 ; v1(129.59,44.49) 129.59,45.13 129.33,45.39 R60471.1 128.67,45.66 127.43,45.66 126.67,44.9 126.67,44.2 CB2.1 126.11,42.65 126.32,42.44 U9.10 ; CB4.1 129.57,33.1 U9.24 ; U17.14 159.48,83.65 v1(159.49,83.66) ; PR243.1 31.42,79.32 31.84,79.73 v1(31.84,79.9) ; C165.1 163.02,85.18 162.8,84.95 162.43,84.95 162.1,84.62 162.1,83.89 162.32,83.68 U16.14 ; RN4.5 25.12,72.83 25.12,72.83 ; SR14.1 27.15,74.85 v1(26.96,75.05) ; R94.1 R93.1 R95.2 15.02,76.78 14.53,77.26 11.99,77.26 R60362.1 10.88,76.15 R60359.1 10.03,76.37 9.58,76.37 8.27,75.06 8.27,74.58 8.64,74.21 9.59,74.21 10.36,73.44 v1(10.36,72.99) ; RN4.3 25.62,72.83 ; v1(31.25,73.6) 31.24,73.59 30.85,73.59 R80.1 ; 24.52,72.82 RN4.7 ; PR228.1 33.72,73.48 v1(33.78,73.42) ; VR2.2 151.89,12.77 v1(151.89,13.07)
  TOP w0.279: U21.16 174.59,52.4 174.32,52.67 v1(174.32,52.83) ; PR8.1 28.97,75.73 28.42,75.18 v1(28.38,75.18) ; U19.1 155.12,56.99 154.92,57.19 C171.1
  TOP w0.305: C85.2 76.59,85.97 75.36,85.97 75.19,85.8 U12.1 ; v1(27.28,58.94) 26.72,58.39 25.86,58.39 25.68,58.56 25.02,58.56
  TOP w0.356: U9.19 126.32,33.23 CB3.1 124.94,32.69 CB1.1
  TOP w0.381: CA13.1 164.47,58.65 163.82,57.99 UA3.4 ; v1(106.07,80.23) 106.66,79.65 106.66,79.27 107.19,78.73 107.19,77.77 107.53,77.42 108.45,77.42 108.74,77.13 108.74,76.45 ; R243.1 109.94,75.93 109.74,76.13 109.06,76.13 108.74,76.45 ; 108.74,76.45 108.66,76.45 108.05,75.84 105.84,75.84 104.98,74.97 R228.1 104.78,74.5 SR29.1 ; v1(163.04,58.54) 163.1,58.49 UA3.5 ; 25.02,58.56 24.92,58.67 22.71,58.67 21.85,57.8 21.41,57.8 20.91,58.31 20.91,60.28 R278.1 20.31,60.88 18.11,60.88 17.4,61.59 v1(17.4,61.59)
  TOP w0.406: C171.1 155.11,57.81 155.63,58.34 155.93,58.34 ; v1(27.28,58.94) 27.66,58.94 27.74,58.87 28.73,58.87 28.97,59.11 PC33.1 ; UA3.1 164.42,55.17 164.49,55.1 CA10.1 ; CA13.1 165.08,58.15 v1(165.32,57.92)
  TOP w0.432: R125.2 171.68,22.54 v1(171.68,22.39)
  TOP w0.457: R414.1 161.18,86.09 C164.1 ; R284.2 v1(153.45,13.02) ; R376.1 184.08,49.34 v1(184.1,49.37) ; v1(75.9,85.4) 76.54,85.4 76.74,85.59 C85.2 ; C165.1 162.77,85.78 162.38,86.17 ; R431.2 159.64,67.59 159.59,67.54 R370.1 ; C194.1 155.93,75.58 v1(155.96,75.56) ; R124.2 171.26,25.43 171.71,25.87 v1(171.71,26.03) ; v1(155.14,66.95) 155.23,67.03 R60370.1 R60371.1 ; C163.1 168.26,81.39 167.41,82.24 v1(167.41,82.36) ; R387.1 184.18,51.07 v1(184.51,51.4) ; SR9208.1 165.56,84.93 v1(165.64,84.93) ; 178.77,49.55 178.78,49.55 179.08,49.24 C199.1 ; R386.1 184.05,50.18 v1(184.1,50.13) ; v1(139.95,76.29) R9203.2
  TOP w0.508: C162.1 169.78,80.79 v1(170.21,80.36) ; R130.1 159.55,13.69 159.12,13.26 v1(158.92,13.26) ; v1(124.92,33.57) CB1.1 ; v1(169.85,20.9) 169.84,20.91 R137.1 ; v1(166.19,55.34) 165.21,55.34 CA10.1 ; C198.1 174.23,53.97 v1(174.26,53.94) ; R129.1 160.12,33.86 v1(160.12,33.45) ; R135.1 169.79,19.86 v1(169.8,19.84) ; R133.2 160.5,30.83 v1(160.5,30.84) ; v1(161.11,87.38) 160.83,87.1 C164.1 ; v1(97.58,6.98) 97.58,6.66 97.08,6.16 95.3,6.16 v1(94.31,5.17) ; v1(130.25,33.42) 130.25,33.14 130.19,33.08 130.19,32.86 130.05,32.72 CB4.1 ; R239.1 117.44,75.27 117.81,74.9 v1(118.31,74.9) ; v1(83.9,80.31) 83.63,80.31 83.02,80.92 82.35,80.92 80.8,82.47 80.8,85.91 v1(79.83,86.87) ; R136.1 169.64,17.99 v1(169.65,18) ; R233.1 182.29,59.74 183.17,60.62 v1(183.59,60.62) ; R227.1 72.44,79.06 v1(72.44,79.85) ; R350.1 v1(133.55,13.38) ; v1(134.6,77.51) 135.35,78.26 PR227.2 ; R426.1 v2(147.65,7.13) 146.45,7.13 145.42,8.17 v1(145.42,10.36) ; v1(135.92,13.34) 136.23,13.34 136.73,12.84 R146.1 ; v1(171.15,83.02) 171.15,83.02 170.93,83.24 R145.1 ; v1(88.34,12.41) 89.23,13.3 v2(89.23,14.32) 89.23,14.93 87.12,17.04 86.88,17.04 86.4,17.52 83,17.52 82.82,17.34 81.48,17.34 GR6.1 ; L3.1 170.9,28.17 v1(170.84,28.11) ; v1(173.56,73.75) 172.88,73.07 R313.1 ; R431.2 v1(160.1,66.77) ; S1R4.1 v1(160.86,46.76) ; v1(181.94,48.55) 180.47,48.55 180.28,48.74 180.28,49.24 ; v1(162.74,87.39) 162.38,87.04 162.38,86.17 ; v1(23.21,19.19) 20.49,16.48 15.1,16.48 13.44,18.14 12.21,18.14 11.02,16.94 11.02,14.59 10.48,14.05 8.14,14.05 6.43,15.77 v1(6.43,17.82) 6.42,17.83 6.42,20.76 v1(6.43,20.77) ; R226.1 72.33,77.61 v1(70.28,77.61) 69.49,78.41 v2(67.01,78.41) 63.77,78.41 63.53,78.66 62.35,78.66 v1(61.72,78.03) 61.35,78.41 D3C8.1 59.38,78.41 59.36,78.42 D3C5.1 ; R138.1 v1(169.78,18.89) ; v1(169.01,53.15) 169.61,53.15 R378.1
  IN1 w0.254: 105.58,79.74 103.2,79.74 102.93,79.47 99.19,79.47 98.68,78.96 v1(97.52,78.96) 97.52,79.56 98.71,80.74 105.56,80.74 v1(106.07,80.23) 105.58,79.74
  IN1 w0.508: v1(63.37,75.85) 61.72,77.5 v1(61.72,78.03) ; v1(177.95,37.13) 179.05,37.13 180.85,35.32 180.85,34.46 v1(183.59,31.72) ; v1(183.59,31.72) 186.64,34.76 v1(188.04,34.76) ; v1(183.59,31.72) 183.5,31.62 183.5,25.85 186.34,23.01 186.34,16.48 v1(184.35,14.5) ; v1(70.28,77.61) 70.28,77.69 v1(72.44,79.85) 74.83,79.85 75.9,80.92 v1(75.9,85.4) ; v1(23.21,19.19) 23.21,19.95 23.79,20.53 29.17,20.53 30.05,19.65 36.76,19.65 38.28,18.13 v1(39.1,18.13)
  IN2 w0.508: v1(139.95,76.29) 139.31,75.65 137.17,75.65 136.81,76.01 136.81,76.98 136.27,77.51 v1(134.6,77.51) 132.73,75.65 121.99,75.65 120.61,74.27 118.69,74.27 118.31,74.65 v1(118.31,74.9)
  IN3 w0.508: v1(17.4,61.59) 17.4,61.33 12.6,56.53 12.6,47.41 9.15,43.96 9.15,40.05 7.49,38.4 7.49,32.81 7.53,32.77 7.53,32.77 7.9,32.4 7.9,32.4 10.11,30.19 10.11,27.96 7.93,25.77 7.93,21.89 6.8,20.77 v1(6.43,20.77)
  BOTTOM w0.178: v1(97.52,78.96) 97.87,79.3 97.87,79.62 97.98,79.73 U10.11
  BOTTOM w0.254: SR51.1 35.44,75.59 v1(35.45,75.58) 35.45,75.29 35.47,75.27 R83.2 ; v1(104.29,69.91) 104.5,70.12 R198.1 R197.1 ; v1(27.28,58.94) 27.21,59.01 U1.K16 U1.K14 ; v1(70.92,85.41) 70.92,85.97 71.35,86.4 71.35,89.44 71.31,89.48 SR72.2 ; PR7.1 33.38,74.12 33.78,73.72 v1(33.78,73.42) 33.78,73.41 SR52.1 ; SR27.1 31.25,73.23 v1(31.25,73.6) ; R252.1 168.06,68.43 168.02,68.39 R251.1 ; PR184.1 122.95,2.13 v1(122.44,1.62) ; v1(10.36,72.99) 10.18,73.18 Q20.1 ; v1(178,79.01) 178.21,79.21 R354.1 ; SR50.1 24.33,74.63 24.51,74.45 R71.1 24.87,75.14 v1(24.72,75.29) ; v1(25.87,79.99) 25.87,79.99 26.56,79.99 PR46.1 ; R92.1 R82.2 27.24,74.76 v1(26.96,75.05) ; SR77.1 159.22,81.16 v1(158.57,80.52) ; R355.1 v1(177.13,81.09) ; v1(70.28,77.61) 70.28,74.21 69.64,73.56 69.64,70.59 69.09,70.05 v1(69.09,69.26) ; R84.2 29.57,75.76 SR8.2 29.06,75.76 28.35,76.47 v1(28.2,76.47) 27.79,76.47 PR45.2 ; v1(31.84,79.9) 32.06,79.68 32.06,79.45 SR62.1 ; SR3.1 29.73,72.88 29.94,73.08 v1(29.94,73.73) ; R253.1 164.91,68.62 165.49,68.62 R254.1 165.7,68.39 v1(164.47,67.15) ; R81.1 28.12,74.62 28.38,74.88 v1(28.38,75.18) ; R256.1 v1(162.98,75.32)
  BOTTOM w0.279: v1(154.13,71.09) 153.91,71.31 U20.4 ; C190.1 159.43,77.87 U20.23 ; v1(154.12,72.73) 154.05,72.81 U20.7 ; U20.36 162.48,69.81 C191.1 ; CON11.15 183.75,88.2 183.34,88.61 v1(180.16,88.61) ; U20.33 160.59,71.31 160.29,71.61 v1(160.29,71.98) ; C192.1 151.8,69.53 152.08,69.81 U20.1 ; U20.16 155.93,75.59 v1(155.96,75.56)
  BOTTOM w0.305: v1(63.37,75.85) 63.37,76.38 v1(61.72,78.03) 61.11,78.65 DIMM1.199
  BOTTOM w0.356: GU1.14 93.25,3.93 93.51,4.19 GC3.1 ; HU4.5 98.38,4.73 98.47,4.63 HC7.1 ; v1(63.37,75.85) 63.98,76.46 63.98,77.67 62.97,78.68 61.69,78.68 61.12,79.25 DIMM1.201 ; GC4.1 97.58,8.4 97.6,8.42 GU2.5
  BOTTOM w0.381: R425.1 25.23,81.27 25.66,80.84 25.66,80.45 25.87,80.23 v1(25.87,79.99) ; R427.1 v1(184.35,14.5) ; v1(94.75,86.43) 94.76,86.43 94.78,86.45 PR233.1
  BOTTOM w0.457: v1(149.23,77.32) 149.26,77.28 R369.1 ; C193.1 150.77,70.4 150.32,69.94 v1(150.32,67.94) ; C101.1 146.4,90.38 v1(146.41,90.39) 146.41,90.38 VCB1.1 147.08,89.75 147.32,89.5 VU1.5 ; VCB4.1 VCB3.1 178.35,36.35 177.98,35.99 VU4.5 ; VCB4.1 178.27,37.44 v1(177.95,37.13) ; VCB4.1 179.56,37.44 VU3.5 ; v1(168.56,67.4) 168.37,67.59 R252.1 ; L4.1 160.67,87.83 v1(161.11,87.38) ; v1(151.65,67.94) 151.8,68.09 C192.1 ; C191.1 162.7,69.27 v1(162.38,68.95) ; v1(146.89,78.83) 146.88,78.85 146.88,79.52 146.72,79.67 VCB2.1 C100.1 145.91,80.48 145.18,81.21 VU2.5 ; v1(159.79,78.45) 159.75,78.49 C190.1
  BOTTOM w0.508: GC4.1 v1(97.58,6.98) ; v1(83.9,80.31) 84.15,80.31 86.23,78.22 87.43,78.22 ; v2(5.98,15.35) 5.95,15.38 PR97.1 5.95,17.34 v1(6.43,17.82) 6.42,17.83 PR110.1 ; v1(166.28,73.91) R255.1 ; v1(88.29,78.66) 87.86,78.66 87.43,78.22 ; VU5.5 187.61,33.91 VCB5.1 188.29,34.51 v1(188.04,34.76) ; PR117.1 19.79,19.19 v1(23.21,19.19) ; v1(94.31,5.17) 94.1,4.96 GC3.1 ; R300.1 v1(183.59,31.72) 183.21,31.34 HR48.1 ; HC7.1 99.52,4.63 99.58,4.69 HR46.1 100.19,4.95 v1(100.66,5.43) ; v1(60.75,88.79) 60.75,88.38 60.38,88.02 PR53.1 ; 87.43,78.22 v1(87.43,78.22) ; v1(104.95,84.6) 105.18,84.37 105.18,81.75 106.07,80.87 v1(106.07,80.23) ; v1(52.63,10.51) 52.63,9.44 51.29,8.1 PC174.1 47.94,9 47.86,9.08 PU9.1 47.86,10.65 47.45,11.07 45.3,11.07 40.42,15.94 39.62,15.94 39.1,16.46 v1(39.1,18.13) ; v1(101.55,6.93) 102.1,7.48 R282.1 ; v1(97.52,78.96) 97.32,79.16 96.75,79.16 C77.1 ; v1(6.43,20.77) 6.44,20.76 PR107.1 ; SR71.2 65.86,87.42 v1(65.77,87.33)
  vias: v1(6.73,79.43) v1(24.94,72.97) v1(115.22,59.04) v1(115.34,56.71) v1(116.02,56.79) v1(156.41,59.28) v1(157.51,52.54) v1(162.66,52.34) v3(114.58,56.67)
+3P3V_DUAL: length 424.9
  TOP w0.254: v1(31.15,85.6) 31.52,85.24 MC4.2 ; v1(31.04,81.01) 31.3,80.75 R331.1 ; U13.13 26.16,83.79 26.32,83.63 26.32,81.81 26.76,81.36 27.8,81.36 28.09,81.65 R326.1 28.72,83.07 28.75,83.04 R325.1 29.26,82.87 28.89,82.5 v1(28.89,81.79) ; 31.77,84.55 32.06,84.55 32.16,84.66 U14.1 ; U13.1 21.32,86.29 20.62,85.59 R324.1 R323.1 20.59,84.61 20.02,84.04 v1(20.02,83.16) ; R332.1 41.34,84.55 41.19,84.4 R333.1 41.19,83.16 41.57,82.78 41.57,82.22 41.24,81.89 40.71,81.89 v1(40.49,81.67) 40.29,81.87 40.29,82.53 R334.1 39.48,82.26 39.18,82.26 MC1.2 MC2.2 38.11,81.35 37.49,81.35 37.14,81.7 37.14,82.01 36.99,82.16 U14.13
  TOP w0.508: v1(107.95,16.27) 107.95,22.19 108.87,23.1 108.87,31.28 105.6,34.55 105.6,35.23 105.18,35.65 104.5,35.65 101.7,38.45 100.51,38.45 97.61,41.34 96.19,41.34 93.94,43.59 93.94,52.43 98.12,56.61 98.12,59.85 100.39,62.12 100.56,62.12 105.14,66.7 107.34,66.7 PR172.1 ; R319.1 174.94,75.33 v1(175.49,75.33) 175.54,75.28 v2(176.38,75.28) ; R353.2 v1(132.41,13.53)
  IN1 w0.254: v1(31.15,85.6) 31.15,84.84 28.89,82.58 v1(28.89,81.79) 30.41,83.3 35.79,83.3 36.83,82.26 36.83,81.86 37.49,81.2 38.48,81.2 39.26,81.97 40.23,81.97 40.49,81.71 v1(40.49,81.67)
  IN1 w0.457: v1(175.49,75.33) 177.2,75.33 179.77,72.75 179.77,69.52 181.1,68.19 181.1,48.18 181.33,47.95 183.44,47.95 184.18,47.21 184.18,44.52 183.87,44.21 182.09,44.21 180.93,43.04 180.93,40.35 178.64,38.07 177.55,38.07 176.68,37.2 173.05,37.2 171.75,35.91 170.56,35.91 169.46,34.81 169.46,32.44 166.35,29.33 159.76,29.33 156,25.56 156,24.61 155.65,24.26 155.15,24.26 154.38,25.04 v1(153.82,25.04) ; v1(145.5,14.8) 145.15,14.45 143.59,14.45 141.3,12.16 132.84,12.16 132.41,12.59 v1(132.41,13.53) 123.14,13.53 122.16,14.51 118.51,14.51 116.99,16.02 108.21,16.02 v1(107.95,16.27)
  IN1 w0.508: v1(175.49,75.33) 173.86,75.33 172.95,74.41 170.18,74.41 169.05,73.28 164.14,73.28 163.68,72.83 159.27,72.83 158.75,73.35 158.75,75.86 157.88,76.74 153.46,76.74 152.58,75.86 146.82,75.86 146.42,76.27 v1(143.71,76.27)
  IN2 w0.254: v1(31.15,85.6) 30.53,84.98 25.17,84.98 22.81,82.61 20.56,82.61 v1(20.02,83.16) ; v1(28.89,81.79) 29.37,82.27 31.25,82.27 31.56,81.96 31.56,81.52 v1(31.04,81.01)
  IN2 w0.508: v1(145.5,14.8) 146.03,15.32 146.03,21.07 149.99,25.04 v1(153.82,25.04) ; v1(40.49,81.67) 41.6,80.56 44.14,80.56 45.28,81.7 49.09,81.7 49.43,82.04 54.87,82.04 55.3,81.61 60.83,81.61 61.65,80.79 65.47,80.79 67.46,82.78 69.19,82.78 69.54,83.13 76.61,83.13 78.22,81.51 82.75,81.51 83.23,82 85.77,82 86.33,81.44 88.69,81.44 89.08,81.04 92.52,81.04 92.89,81.41 93.99,81.41 94.93,80.47 98.44,80.47 99.24,81.28 101.56,81.28 101.77,81.49 107.87,81.49 108.09,81.27 108.34,81.27 109.56,80.05 109.56,79.97 109.93,79.61 113.89,79.61 114.33,80.05 120.34,80.05 121.04,80.75 127.17,80.75 127.44,81.02 136.72,81.02 137.39,80.36 140.05,80.36 140.76,79.65 142.52,79.65 143.71,78.45 v1(143.71,76.27)
  BOTTOM w0.508: 39.05,86.46 39.31,86.2 40.68,86.2 40.95,86.46 PC202.1 41.83,85.91 PQ33.2 40.36,84.44 40.36,83.94 39.96,83.53 39.96,82.27 40.49,81.73 v1(40.49,81.67)
+3P3V_DUAL_F:
  vias: v2(29.41,82.67)
+3P3V_DUAL_G_B: length 6.4
  BOTTOM w0.381: PQ33.1 41.99,81.98 43.71,81.98 v2(44.17,81.53) 44.77,81.53 PR223.2 45.25,82.55 45.16,82.64 PC203.1
+3P3V_DUAL_P: length 0.9
  BOTTOM w0.254: v2(35.61,83.89) 35.74,84.02 35.74,84.73
+3P3V_EDP: length 28
  TOP w0.203: U6.53 167.78,21.52 C9212.1 ; C9213.1 162.34,29.19 162.59,28.95 162.59,27.88 162.49,27.79 U6.8 ; U6.25 157.58,22.72 157.51,22.65 C9209.1 ; U6.63 166.6,25.52 166.8,25.72 167.21,25.72 167.27,25.66 C9210.1 ; 159.44,28.86 160.05,28.25 160.05,27.75 160.49,27.31 U6.13 ; v1(161.88,16.98) 161.88,17.26 161.69,17.45 U6.39 ; C9215.1 159.01,17.13 159.01,18.46 159.29,18.74 U6.33
  TOP w0.254: v1(169.85,28.26) 170.54,27.58 171.45,27.58 v2(172.09,28.21)
  TOP w0.432: v1(162.1,28.24) 162.1,29.1 C9213.1 ; v1(167.01,26.26) 167.36,26.26 167.86,25.76 C9210.1 ; C9214.1 161.73,16.84 v1(161.88,16.98) ; v1(158.37,17.44) 158.37,17.07 C9215.1 ; v1(159.44,28.16) C9211.1 ; v1(167.21,22.19) 167.76,22.19 C9212.1
  TOP w0.457: v1(156.49,22.03) 156.5,22.03 156.83,22.35 C9209.1
  TOP w0.508: C60.1 168.31,29.06 168.35,29.1 L3.2 169.85,28.88 v1(169.85,28.26)
+3P3V_G_B: length 4.8
  BOTTOM w0.254: v2(114.37,59.89) PQ27.1 113.49,58.33 113.13,57.97 PC189.1 113.13,57.23 113.12,57.23 PR198.2
+3P3V_HK: length 11.2
  TOP w0.457: R352.1 R351.1
  TOP w0.508: v1(133,10.27) 133.55,10.83 R350.2 R353.1 v1(132.41,10.94) 131.97,10.49 v2(131.78,10.49) ; R351.1 v1(134.7,13.23)
  BOTTOM w0.279: CON9.6 v1(133,10.27)
  BOTTOM w0.508: v1(132.41,10.94) 132.82,11.35 134.37,11.35 134.7,11.68 v1(134.7,13.23)
+3P3V_MINI1: length 5.1
  TOP w0.432: R306.1 176.65,58.45 v1(176.84,58.26)
  TOP w0.457: v1(176.81,56.57) 176.8,56.56 176.8,56.53 176.77,56.51 R450.1
  TOP w0.508: v1(174.22,62.5) 174.5,62.78 R305.1 ; v2(175.95,64.89) 175.36,65.47 v3(175.24,65.47)
  BOTTOM w0.762: R312.2 176.68,64.44 176.68,64.54 175.74,65.47 v3(175.24,65.47)
  vias: v1(171.93,59.89) v1(172.01,60.6) v1(175.19,64.33) v1(175.87,38.75) v1(176.51,38.75)
+3P3V_MSATA: length 33.8
  TOP w0.457: v1(105.39,15.69) 107.37,17.67 107.37,22.42 v2(105.44,24.35)
  TOP w0.508: v2(105.44,24.35) 103.2,26.58 103.2,33.17 v1(104.93,34.89)
  BOTTOM w0.279: CONSATA.70 104.88,15.08 ; CONSATA.72 104.89,14.58 ; CONSATA.74 104.84,14.08
  BOTTOM w0.406: 104.19,34.98 C126.1 104.73,35.49 ; 103.33,34.98 C127.2
  BOTTOM w0.508: 105.23,14.01 102.94,11.71 SC7.1 102.94,10.49 102.87,10.43 C125.1 102.87,9.49 102.92,9.44 R282.2
+3P3V_SATA: length 7.1
  TOP w0.508: 184.96,58.03 184.96,60.29 v2(183.95,61.31) ; 183.57,55.22 R234.1 184.1,54.72
  TOP w0.635: 186.07,55.89 CON3.P2 ; 186.07,54.62 CON3.P1 ; 186.07,57.16 CON3.P3
+3P3V_SPI: length 15.5
  TOP w0.102: PR227.1 134.61,79.15 v2(134.34,78.88)
  TOP w0.254: F3J1.2 137.54,82.41 137.34,82.21 135.92,82.21 F3CB4.1
  TOP w0.508: v1(137.86,80.99) 137.42,80.55 F3R14.1 135.46,80.55 PR229.1 ; PR229.1 135.4,81.69 F3CB4.1 ; PR229.1 135.46,80.42 PR227.1
  BOTTOM w0.457: F3R3.1 139.54,80.08 138.35,80.08 C53.1
  BOTTOM w0.508: F3R3.1 139.61,80.78 139.21,81.18 F3U1.8 ; C53.1 138.31,80.53 137.86,80.98 v1(137.86,80.99) 137.86,81.78 F3R2.1
+3P3VA: length 11.2
  TOP w0.254: v1(121.94,61.13) 121.67,61.41 v2(121.21,61.41)
  TOP w0.457: v1(121.94,61.13) 121.94,60.32 PC119.1
  TOP w0.508: v1(123.4,60.45) 122.7,59.76 PC119.1
  IN2 w0.508: v1(121.94,61.13) 120.14,61.13 119.46,61.81 118.94,61.81 118.47,61.33 v1(118.47,60.24)
  BOTTOM w0.203: PU6.3 v1(123.4,60.45)
  BOTTOM w0.254: PR155.1 117.57,60.45 117.78,60.24 v1(118.47,60.24)
+3P3VSB: length 376.9
  TOP w0.254: v1(48.26,74.24) 48.24,74.24 ; 48.24,74.24 48.36,74.12 RN1.1 ; 48.24,74.24 48.11,74.24 47.71,73.83 RN1.3 ; RN3.3 49.33,73.83 v1(49.68,74.19) 49.98,73.89 RN3.1 ; SR28.1 34.34,77.63 34.32,77.65 PR37.1 33.19,77.65 33.12,77.72 ; RN8.4 44.7,72.5 v1(45.04,72.84) ; 33.12,77.72 32.84,77.44 32.84,77.2 32.55,76.91 32.55,76.43 33.15,75.84 33.15,74.22 32.61,73.68 32.61,72.46 SR35.1 ; 33.12,77.72 33.07,77.77 33.07,78.6 32.65,79.02 PR242.1 32.46,79.77 v1(32.59,79.9) ; v1(44.24,72.84) 44.24,71.91 44.05,71.72 RN8.2 ; GR4.1 58.13,4.36 56.77,4.36 v1(56.21,4.92) ; PR20.1 40.4,75.06 40.58,75.24 v1(40.58,75.78) 40.58,76.24 40.79,76.46 SR80.1 41.51,76.75 SR36.1 ; SR81.1 42.11,72.91 42.11,73.33 42.13,73.34 v1(42.13,73.33)
  TOP w0.457: HR10.1 63.74,70.45 63.97,70.45 64.22,70.21 64.22,69.86 v1(64.52,69.56)
  TOP w0.508: v1(109.04,17.87) 109.04,18.94 109.48,19.38 109.48,32.99 102.03,40.43 102.03,42.41 ; v1(133.76,79.42) 133.76,79.74 PR229.2 ; v1(124.92,86.83) 124.94,86.81 CR9.1 ; CR4.1 121.26,86.14 v1(121.26,86.76) 121.26,86.94 120.75,87.44 119.31,87.44 118.85,87.9 118.14,87.9 117.83,87.6 117.83,86.27 CR7.1 119.46,84.64 119.46,83.96 118.26,82.77 118.26,82.39 117.37,81.5 117.37,79.3 116.78,78.71 115.04,78.71 114.5,78.17 CR3.1 ; v1(123.24,79.34) 122.71,78.81 122.71,76.56 R240.1 ; v1(112.07,77.94) 112.07,79.04 113.16,80.13 113.16,81.42 114.08,82.35 114.08,84.64 113.71,85.01 CR2.1
  TOP w1.27: 98.78,42.41 102.03,42.41 103.13,43.5 103.13,44.55 104.65,46.07 108.02,46.07 109.23,47.29 109.23,53.57
  IN1 w0.254: v1(31.32,22.95) v1(32.46,22.95) v1(33.73,22.95) ; v1(40.58,75.78) 40.58,77.22 39.9,77.89 39.9,79.01 39.35,79.57 38.13,79.57 37.52,80.18 32.87,80.18 v1(32.59,79.9)
  IN1 w0.508: v1(125.09,77.92) 124.66,77.92 v1(123.24,79.34) 122.62,78.72 112.67,78.72 112.07,78.11 v1(112.07,77.94) ; v1(133.76,79.42) 135.97,81.63 152.99,81.63 157.34,85.97 v1(167.34,85.97) ; v1(124.92,86.83) 124.54,86.83 123.92,87.46 121.58,87.46 121.26,87.14 v1(121.26,86.76)
  IN2 w0.254: v1(32.59,79.9) 31.92,79.23 28.61,79.23 26.24,76.85 25.4,76.85 24.89,76.34 23.37,76.34 22.98,75.95 22.98,75.57 21.91,74.5 v1(21.91,73.54) ; v1(45.54,20.31) 45.32,20.54 41.78,20.54 40.93,21.39 34.87,21.39 34.34,21.91 34.34,22.7 34.09,22.95 v1(33.73,22.95)
  IN2 w0.508: v1(133.76,79.42) 130.94,79.42 129.8,78.27 129.8,77.84 129.25,77.3 126.58,77.3 v1(125.96,77.92) ; 60.1,69.3 62.85,69.3 63.12,69.56 v1(64.52,69.56) ; 60.1,69.3 58.9,68.1 58.9,64.79 57.48,63.36 56.29,63.36 v1(55.7,63.95) ; 60.1,69.3 57.47,69.3 55.7,71.07 v1(55.7,72.06) ; v1(174.42,78.66) 172.74,76.98 171.93,76.98 171.02,77.89 171.02,80.43 170.26,81.2 170.26,83.05 v1(167.34,85.97)
  BOTTOM w0.254: GR34.1 31.19,23.08 v1(31.32,22.95) ; v1(21.91,73.54) 21.91,73.87 22.04,74.01 SR4.1 ; PR33.1 44.82,73.06 v1(45.04,72.84) ; GR32.1 v1(32.46,22.95) ; R109.1 44.63,72.68 44.48,72.84 v1(44.24,72.84) 44.2,72.84 43.81,72.45 R119.1 ; v1(56.21,4.92) 56.21,5.02 53.93,7.31 53.93,10.81 53.49,11.24 v2(49.76,11.24) 48.16,11.24 47.7,11.7 45.89,11.7 43.71,13.88 43.71,15.51 45.18,16.97 45.18,19.94 v1(45.54,20.31) ; GR33.1 v1(33.73,22.95) ; SR82.1 37.09,72.86 37.03,72.92 37.03,73.18 v1(36.87,73.34) ; R405.1 40.44,75.54 40.57,75.67 40.57,75.79 40.58,75.79 v1(40.58,75.78) 40.59,75.79 41.47,75.79 41.72,75.54 SR79.1 ; v1(42.13,73.33) 42.13,73.34 42.11,73.33 42.11,73.1 R406.2 ; R407.2 39.07,73.12 38.76,73.42 v1(38.43,73.42)
  BOTTOM w0.508: v1(52.42,79.65) 52.42,80.31 PR42.1 ; v1(123.24,79.34) 123.24,79.37 126.32,82.44 126.32,85.64 126.95,86.28 126.95,87.11 126.52,87.55 125.63,87.55 v1(124.92,86.83) ; v1(174.42,78.66) 174.42,78.02 176.37,76.08 176.37,75.65 177.37,74.64 178.03,74.64 179.13,73.54 Q24.2 ; R88.1 55.5,63.08 SR1.1 55.44,63.69 v1(55.7,63.95) ; v1(56.21,4.92) 56.21,4.44 58.97,1.67 87.21,1.67 88.5,2.96 96.34,2.96 96.7,2.61 102.57,2.61 104.02,4.06 104.02,11.66 104.72,12.37 108.11,12.37 109.04,13.3 v1(109.04,17.87)
  vias: v1(124.54,72.1) v1(126.09,72.1) v2(108.92,52.54) v2(109.93,54.32) v2(125.3,76.42) v2(125.38,73.45) v3(96.65,43.15) v3(97.54,42.92) v3(110.9,54.48) v3(110.9,53.59)
+3P3VSB_G1_B: length 4.1
  TOP w0.102: v2(100.52,40.46) v1(99.77,40.46)
  BOTTOM w0.381: PR238.2 100.65,39.21 PC225.1 100.01,40.22 v1(99.77,40.46) 99.76,40.46 99.52,40.7 PQ36.1
+3P3VSB_G_B: length 4.3
  TOP w0.102: v2(105.23,39.46) v1(104.47,39.46)
  BOTTOM w0.102: v1(104.47,39.46) 104.47,39.89 104.34,40.02 PQ35.4
  BOTTOM w0.381: PQ35.4 103.85,39.85 103.43,39.44 PR235.1 PR238.1
+A/D_DOCK_IN: length 75.9
  TOP w0.508: v1(120.98,20.64) 119.89,19.55 v2(119.13,19.55) 112.76,19.55 111.25,18.04 111.25,16.86 107.27,12.87 105.28,12.87 104.19,11.79 104.19,11.12 100.94,7.87 99.64,7.87 96.33,4.55 89.99,4.55 89.8,4.74 v2(89.23,4.74) v1(88.22,4.74) ; v1(125.83,22.32) 126.95,23.44 129.36,23.44 133.28,27.35 133.28,30.93 134.77,32.43 v2(134.77,38.83) 134.77,39.79 PR69.1
  BOTTOM w0.508: v1(125.83,22.32) 122.66,22.32 v1(120.98,20.64) ; v1(88.22,4.74) 88.22,3.78 87.3,2.86 84.38,2.86 83.62,3.62
  vias: v2(15.52,57.17) v2(83.14,3.52) v3(1.85,13.55) v3(1.86,12.59) v3(1.88,11.63) v3(2.74,12.21) v3(13.23,61.17) v3(13.82,60.49) v3(14.12,61.42) v3(14.72,60.36) v3(82.45,5.25) v3(82.5,4.36) v3(83.47,5.28) v3(83.47,4.36)
+A/D_DOCK_IN_B:
  vias: v2(78.2,7.94)
+AC_BAT_IN: length 194.6
  TOP w0.508: 7.38,69.04 PC56.1 7.98,69.64
  IN1 w0.254: v1(110.68,35.64) 110.68,35.95 110.34,36.29 108.18,36.29 106.95,37.52 106.95,41.19 107.96,42.21 107.96,54.75 107.55,55.16 107.55,62.28 105.02,64.81 103.57,64.81 101.86,66.52 101.86,67.99 99.01,70.83 99.01,74.49 98.02,75.48 96.9,75.48 94.27,78.11 90.24,78.11 89.4,77.27 84.23,77.27 82.92,78.58 72.06,78.58 70.42,76.94 69.06,76.94 68.56,77.45 68.56,78.32 63.96,82.91 63.16,82.91 62.66,82.41 58.1,82.41 55.65,84.86 v1(55.65,86.71)
  IN3 w0.254: v1(110.68,35.64) 112.92,37.89 124.61,37.89 125.55,38.83 126.08,38.83 126.3,39.04 134.1,39.04 137.49,42.44 137.49,43.57 139.18,45.26 v1(139.18,45.33) ; v1(12.45,68.44) 12.45,70.4 13.72,71.67 15.33,71.67 16.96,73.29 16.96,78.81 18.39,80.24 18.39,82.03 19.41,83.05 19.41,83.76 20.27,84.62 22.25,84.62 25.96,88.33 38.03,88.33 39.28,87.08 51.88,87.08 53.14,88.33 54.53,88.33 55.65,87.21 v1(55.65,86.71)
  BOTTOM w0.254: PR76.1 139.52,46.53 139.49,46.49 139.49,45.65 139.18,45.35 v1(139.18,45.33)
  vias: v2(11.81,69.7)
+AC_BAT_SYS: length 313.8
  TOP w0.254: v1(50.75,90.45) 45.42,90.45 v3(45.32,90.56)
  TOP w1.27: 43.24,90.1 22.64,90.1
  TOP w1.778: 47.96,10.28 47.96,6.47
  TOP w2.286: 44.81,7.21 44.81,8.4
  TOP w4.064: 16.46,3.52 22.03,3.52 26.03,7.53 30.04,7.53 ; 44.98,11.45 41.1,15.33
  TOP w4.572: 151.61,54.35 151.61,47.62 152.96,46.27 152.96,38.8 150.5,36.34 150.5,27.14
  IN1 w1.27: 45.92,2 89,2
  IN1 w2.032: 10.82,3.35 10.82,7.47 3.61,14.68 3.61,16.07
  IN2 w1.27: 46.79,1.95 88.9,1.95
  IN2 w2.032: 3.61,16.04 3.61,14.74 10.77,7.58 10.77,3.42
  IN3 w1.143: 3.66,88.94 3.66,89.45 4.68,90.47 19.56,90.47
  IN3 w1.524: 46.22,2.14 87.78,2.14
  BOTTOM w0.254: PR50.1 59.7,90.67 51.94,90.67 51.73,90.45 v1(50.75,90.45)
  BOTTOM w0.508: PR239.1 108.99,36.87 109.58,37.46 109.58,38.57 ; R275.1 42.78,87.72 45.01,87.72 45.59,88.31 ; 140.36,15.56 140.9,15.56
  BOTTOM w1.524: 119.45,35.74 118.39,34.69 118.39,32.94 117.59,32.14 113.45,32.14 112.21,33.38 112.21,37.57 111.2,38.57 109.58,38.57 107.59,40.57 107.59,41.41
  BOTTOM w4.064: 152.58,48.76 152.58,60.34 145.66,67.27
  vias: v1(161.47,13.94) v1(161.48,13.3) v3(1.91,17.75) v3(1.93,16.83) v3(1.93,15.89) v3(1.96,14.98) v3(4.18,63.29) v3(4.18,64.2) v3(4.18,62.29) v3(4.18,61.34) v3(4.18,60.42) v3(9.82,3.88) v3(10.29,4.74) v3(10.72,3.85) v3(11.23,4.74) v3(11.62,65.23) v3(11.62,64.33) v3(11.62,63.44) v3(11.63,3.84) v3(12.04,62.65) v3(12.53,3.82) v3(20.6,90.26) v3(21.57,90.26) v3(43.68,2.51) v3(44.02,1.68) v3(44.25,90.56) v3(44.58,2.53) v3(44.91,1.68) v3(45.47,2.49) v3(45.84,1.68) v3(89.1,1.74) v3(90.02,1.69) v3(90.91,1.68) v3(91.8,1.68) v3(92.69,1.68) v3(93.58,1.69) v3(125.23,2.51) v3(125.38,3.52) v3(126.32,3.52) v3(126.32,2.51) v3(127.2,3.52) v3(127.2,2.51) v3(139.32,14.11) v3(139.9,14.95) v3(140.16,67.94) v3(140.29,14.06) v3(140.42,68.79) v3(140.79,14.95) v3(141.05,67.94) v3(141.3,14.06) v3(141.48,68.78) v3(141.68,14.95) v3(141.94,67.94) v3(142.44,67.07) v3(142.68,68.78) v3(142.95,67.94)
+AC_SN_C:
  vias: v2(13.34,51.87)
+AC_SN_C1:
  vias: v2(16.87,51.86)
+ADAPTER_IN: length 170.5
  TOP w0.254: PR70.1 139.88,34.95 v1(138.79,34.95)
  IN2 w0.254: v3(8.61,52.46) 10.48,52.46 12.32,54.3 23.83,54.3 24.3,54.77 33.49,54.77 34.27,53.99 34.27,53.14 35.04,52.37 35.34,52.37 36.04,51.67 36.04,49.09 35.89,48.94 35.89,42.03 36.94,40.99 37.25,40.99 38.27,39.97 38.66,39.97 39.58,39.05 40.15,39.05 40.18,39.08 41.25,39.08 41.76,38.57 45.44,38.57 46.29,37.72 46.29,36.46 50.55,32.2 50.55,31.09 54.62,27.02 57.41,27.02 60.89,23.54 65.87,23.54 67.95,21.46 67.95,19.42 69.5,17.87 69.68,17.87 v1(69.7,17.85)
  IN3 w0.254: v1(138.79,34.95) 135.55,31.72 134.77,31.72 132.59,29.53 121.44,29.53 118.85,32.12 105.82,32.12 103.68,34.26 98.76,34.26 98.05,33.55 95.13,33.55 93.85,32.28 92.58,32.28 90.7,30.4 90.7,29.53 87.07,25.9 87.07,24.25 84.61,21.79 84.08,21.79 82.35,20.06 77.86,20.06 75.49,17.69 74.02,17.69 73.1,18.61 72.32,18.61 71.55,17.85 v1(69.7,17.85)
  vias: v2(9.6,52.9) v3(8.33,54.36) v3(8.35,53.39) v3(8.5,55.32)
+DUAL_POWER_G_B: length 141.8
  TOP w0.356: v1(127.59,59.78) 127.91,60.11 PQ32.4
  TOP w0.381: v1(130.84,68.29) 130.84,68.44 131.68,69.28 v2(133.58,69.28) 134.98,69.28 139.42,73.73 139.42,75.46 139.01,75.86 v1(139.01,76.27) ; v1(130.11,56.44) 130.43,56.12 PR212.1 131.03,55.85 131.78,55.85 132.42,55.21 PR206.1 132.92,55.21 133.3,55.59 v1(133.3,55.97)
  IN1 w0.508: v1(133.3,55.97) 132.54,55.97 132.15,56.37 131.72,56.37 128.3,59.78 v1(127.59,59.78)
  IN2 w0.381: v1(130.84,68.29) 130.84,67.73 131.22,67.35 131.22,64.91 130.11,63.81 v1(130.11,56.44) ; v1(139.01,76.27) 135.21,80.07 130.04,80.07 128.75,78.78 121.12,78.78 119.4,77.06 115.09,77.06 113.49,78.66 109.35,78.66 108.6,79.41 97.86,79.41 97.76,79.52 94.53,79.52 94.3,79.75 92.77,79.75 92.46,80.05 88.79,80.05 88.48,79.74 83.05,79.74 82.23,80.56 77.83,80.56 76.23,82.16 69.92,82.16 69.59,81.83 68.95,81.83 67.96,80.84 67.01,80.84 66.01,79.84 61.76,79.84 61.13,79.2 59,79.2 57.54,80.66 54.9,80.66 54.47,81.09 49.82,81.09 48.81,80.07 46.31,80.07 46,80.38 v1(45.55,80.38)
  BOTTOM w0.381: v1(45.55,80.38) 45.55,80.93 46.09,81.48 PR223.1
