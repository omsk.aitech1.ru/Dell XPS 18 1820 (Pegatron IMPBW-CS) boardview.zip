# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Nets (continued)
+VCORE_IMON_A: PC85.1 PR127.1 PU4.13
+VCORE_IN: PC87.1 PC88.1 PC90.1 PJP8.2 PL10.1 PU5.5
+VCORE_IN_A: PJP8.1 PR106.1
+VCORE_MODE_A: PR132.1 PU4.4
+VCORE_O-USR_A: PR125.2 PR126.1 PU4.9
+VCORE_OCP-I_A: PR129.1 PR224.2 PU4.12
+VCORE_PWM1: PU4.6 PU5.8
+VCORE_SCLK_A: PR99.2 PR104.1 PU4.31
+VCORE_SDA_A: PR100.2 PR101.1 PU4.1
+VCORE_SKIP#: PR134.2 PU4.7 PU5.1
+VCORE_SLEWA_A: PR118.2 PR119.1 PU4.15
+VCORE_SN1_C: PC94.1 PR137.2
+VCORE_SW1_R: PJP9.2 PL12.1 PR137.1 PU5.4
+VCORE_THERM_A: PC84.1 PR120.1 PRT5.2 PU4.14
+VCORE_V5A_C: PC76.1 PR103.2 PU4.28
+VCORE_VBAT_A: PR106.2 PU4.16
+VCORE_VDD_C: PC75.1 PR97.2 PU4.2
+VCORE_VFB_A9: PR128.2 PR130.2 PU4.24
+VCORE_VREF_A: PC83.1 PR115.2 PR118.1 PR121.1 PR123.1 PR125.1 PRT5.1 PU4.27
+VCOREB_RAMP_A: PR121.2 PR122.1 PU4.11
+VTT_DDR: C8.1 C9.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 D3CE36.1 D3CE37.1 D3CE38.1 D3CE39.1 D3CE40.1 D3CE41.1 DIMM1.203 DIMM1.204 PC157.1 PC158.1 PR176.1 PR234.2 PU7.20 R1.2 R2.2 R3.2 R4.2 R5.2 R6.2 R7.2 R8.2 R9.2 R10.2 R11.2 R12.2 R13.2 R14.2 R15.2 R16.2 R17.2 R18.2 R19.2 R20.2 R21.2 R22.2 R23.2 R24.2 R25.2 R26.2 R27.2 R28.2
+VTT_DDR_VTTSNS_A: PR176.2 PR234.1 PU7.2
+VTTREF_A: PC159.1 PU7.4
A20GATE: SR29.2 U10.126
A_DE: R387.2 R389.1 U21.9
A_EQ1: R381.2 R385.1 U21.18
A_EQ2: R380.2 R384.1 U21.19
AC_IN_OC: PR90.2 T61.1
AC_IN_OC#: PQ10.6 R174.2 T60.1 U10.120
AC_IN_OC_EC: PR29.2 PR31.1 U10.98
AC_PRESENT_R: PR31.2 U1.AJ8
ACC_INT1_IO: R359.2 U17.11 U20.28
ACC_INT1_IO_R: C184.1 CON11.7 R359.1
ACC_INT2_IO: R358.2 U17.9 U20.29
ACC_INT2_IO_R: C183.1 CON11.6 R358.1
ACZ_SDIN0: CON10.34 U1.AY10
ADAP_ID_VOL_D: Q36.1 Q37.3 R345.2
ADAP_ID_VOL_G: Q37.1 R344.2 R346.1
ALL_SYSTEM_PWRGD: R410.1 R60469.2 T9200.1 U10.68
AUDIO MODE: CON10.3 R60464.2
AUDIO MODE_R: R9330.2 R60464.1 U1.Y1
AZ_BITCLK: AC1.1 AR1.2 CON10.31
AZ_RST#: AC3.1 AR3.2 CON10.33
AZ_SDATA_OUT_R: AC4.1 AR4.2 CON10.35
AZ_SYNC: AC2.1 AR2.2 CON10.36
B_DE: R386.2 R388.1 U21.8
B_EQ1: R379.2 R383.1 U21.20
B_EQ2: R378.2 R382.1 U21.17
BACK_EN_C: P2.36 R290.1 R291.1 R293.1 VU4.4
BAT1_IN_OC#: PQ9.6 R199.2 T58.1 U10.86
BAT_ALERT: CON8.7 T51.1
BATLOW#: PR30.2 U1.AN4
BBS_BIT0: R71.2 R103.1 U1.J2
BBS_BIT1: R106.1 R416.2 U1.G1
BIST_EN: R285.2 U10.35
BKLT_CTRL: R286.2 U6.47 VU3.2
BL_EN: R290.2 U6.15 VU4.2
CAM_DET_CBL#: CON6.11 R144.1 SR77.2 U1.Y3
CATERR#: HT98.1 R244.1 U1.K61
CFG0: HR37.2 U1.AC60 XDP1.9
CFG1: HR38.2 U1.AC62 XDP1.11
CFG2: HT14.1 U1.AC63 XDP1.15
CFG3: GR22.2 HT15.1 U1.AA63 XDP1.17
CFG3_R: GR22.1 XDP1.60
CFG4: HR39.2 U1.AA60 XDP1.27
CFG5: HT16.1 U1.Y62 XDP1.29
CFG6: HT20.1 U1.Y61 XDP1.33
CFG7: HT22.1 U1.Y60 XDP1.35
CFG8: HR40.2 U1.V62 XDP1.10
CFG9: HR41.2 U1.V61 XDP1.12
CFG10: HR42.2 U1.V60 XDP1.16
CFG11: HT25.1 U1.U60 XDP1.18
CFG12: HT27.1 U1.T63 XDP1.28
CFG13: HT28.1 U1.T62 XDP1.30
CFG14: HT30.1 U1.T61 XDP1.34
CFG15: HT31.1 U1.T60 XDP1.36
CFG16: HT34.1 U1.AA62 XDP1.6
CFG17: HT36.1 U1.AA61 XDP1.4
CFG18: HT35.1 U1.U63 XDP1.24
CFG19: HT38.1 U1.U62 XDP1.22
CFG_RCOMP: HR44.1 U1.V63
CHG_ACDRV_A: PR75.2 PU3.4
CHG_ACDRV_A1: PC55.2 PC56.2 PQ11.4 PQ12.3 PR75.1
CHG_ACN_A: PC60.2 PC61.1 PJP3.1 PU3.1
CHG_ACOK_A: PR83.2 PR90.1 PU3.5
CHG_ACP_A: PC57.1 PC60.1 PJP2.1 PU3.2
CHG_BATDRV_A: PR84.1 PU3.11
CHG_BATDRV_R_A: PC58.1 PQ14.3 PR84.2
CHG_BTST_D: PR86.1 PU3.17
CHG_BTST_R_D: PC66.1 PD4.3 PR86.2
CHG_CMSRC_A: PR76.2 PU3.3
CHG_HIDRV_D: PQ15.3 PR91.1 PU3.18
CHG_ILIM_A: PR80.2 PR87.1 PU3.10
CHG_LODRV_D: PR94.1 PU3.15
CHG_LODRV_D1: PQ16.3 PR94.2
CHG_PHASE_S: PC66.2 PL9.1 PQ15.4 PQ15.8 PQ16.1 PQ16.2 PQ16.5 PQ16.6 PQ16.7 PR91.2 PU3.19
CHG_REGN_D: PC64.1 PD4.1 PD4.2 PU3.16
CHG_SCL_A: PR81.2 PR88.1 PU3.9
CHG_SDA_A: PR82.2 PR89.1 PU3.8
CHG_SRN_A_R: PC70.2 PC72.1 PJP5.1 PR96.2
CHG_SRP_A_R: PC70.1 PC71.1 PJP4.1 PR95.2
CHG_VCC1_D: PD3.3 PR78.1
CHG_VCC_D: PC59.1 PR78.2 PU3.20
CK32KE: CKC6.1 U20.9 X3.2
CK_33M_TPM: CKC7.1 CKR5.2 U9.21
CK_100M_CPUXDP: GR8.1 U1.A35
CK_100M_CPUXDP#: GR11.1 U1.B35
CK_100M_LVDS: PR232.2 U1.B39
CK_100M_LVDS#: PR231.2 U1.A39
CK_100M_LVDS#_R: PR231.1 U6.31
CK_100M_LVDS_R: PR232.1 U6.30
CK_100M_MSATA: CONSATA.55 U1.C37
CK_100M_MSATA#: CONSATA.53 U1.B38
CLK_DEBUG: CKC4.1 CKR4.2 CON5.12
CLK_DEBUG_R: CKR4.1 CKR5.1 U1.AP15
CLK_KBCPCI: CKC3.1 CKR3.2 U10.13
CLK_KBCPCI_PCH_R: CKR3.1 U1.AN15
CLK_PCIE1_WLAN#_PCH: CONWIFI.49 U1.B41
CLK_PCIE1_WLAN_PCH: CONWIFI.47 U1.A41
CLK_PCIE2_WLAN#_PCH: CONWIFI.73 U1.C41
CLK_PCIE2_WLAN_PCH: CONWIFI.71 U1.B42
CLK_PCIE_CR: CON10.43 U1.A37
CLK_PCIE_CR#: CON10.44 U1.B37
CLK_REQ0#: R84.1 U1.U2
CLK_REQ1_WLAN#: CONWIFI.53 R80.2 R85.1 U1.Y5
CLK_REQ2#: R83.1 R400.1 U1.AD1
CLK_REQ4#: R79.1 R401.1 U1.U5
CLK_REQ6_CR#: CON10.47 R81.2 R86.1 U1.T2
CLK_SEL: R133.1 R134.2 U6.10
CLK_XDP_N_R: GR11.2 XDP1.42
CLK_XDP_P_R: GR8.2 XDP1.40
CLKREQ#_MSATA: CONSATA.52 R82.1 R87.1 U1.N1
CM1: T36.1 U13.14
CM2: T38.1 U14.14
CONFIG_0: CONSATA.21 PQ8.1 SR78.1 SR79.2 U1.AP1
CONFIG_1: CONSATA.69 PQ7.1 SR80.2 U1.AL4
CONFIG_2: CONSATA.75 SR81.2 U1.AT5
CONFIG_3: CONSATA.1 SR82.2 U1.AH4
CPU_PWR_DEBUG: GR25.2 GR27.1 GU2.4 U1.H59
CPU_VARY_BL: GR39.2 U6.48
CPU_VR_EN: HR28.1 HR31.1 PR102.1
CPU_VR_EN_R: HR28.2 U1.F60
CPU_VR_READY: R60477.1 U10.34
CPU_VR_READY_R: HC8.1 HR29.1 HR31.2 R60477.2
CPU_VR_READY_RR: HR29.2 U1.C59
CPU_VRON: PR217.1 U10.84
CURRENT_MODIFY: C72.1 PC69.1 PU3.7 U10.72
DC_IN_ID_ADAP: D18.3 R202.2 R343.2 U10.118
DC_IN_ID_ADAP_B: L8.1 U15.3
DC_IN_ID_ADAP_Q: C156.1 L8.2 Q36.3 R344.1
DC_IN_ID_ADAP_R: Q36.2 R343.1
DC_IN_ID_POGO: D15.3 R201.2 R339.2 U10.85
DC_IN_ID_POGO_B: D16.1 J1.3 L7.1
DC_IN_ID_POGO_Q: C153.1 L7.2 Q34.3 R341.1
DC_IN_ID_POGO_R: Q34.2 R339.1
DC_TEST_A3_B3: U1.A3 U1.B3
DC_TEST_A61_B61: U1.A61 U1.B61
DC_TEST_AY2_AW2: U1.AW2 U1.AY2
DC_TEST_AY3_AW3: U1.AW3 U1.AY3
DC_TEST_AY61_AW61: U1.AW61 U1.AY61
DC_TEST_AY62_AW62: U1.AW62 U1.AY62
DC_TEST_B62_B63: U1.B62 U1.B63
DC_TEST_C1_C2: U1.C1 U1.C2
DDPB_AUXN: S1C1.1 U1.C5
DDPB_AUXN_C: CONWIFI.20 S1C1.2 S1R4.2
DDPB_AUXP: S1C2.1 U1.B5
DDPB_AUXP_C: CONWIFI.22 S1C2.2 S1R5.1
DDPB_CTRLDATA: R60359.2 U1.C9
DDPB_HPD: CONWIFI.31 R60364.1 U1.C8
DDPC_CTRLDATA: R60362.2 U1.D11
DDR3_DRAMRST#: C1.1 D3C7.1 DIMM1.30 R38.2 R39.2 U2.T2 U3.T2 U4.T2 U5.T2
DDR_PG_CTRL: HQ2.1 HR10.2 HR11.2 HR13.1 HU1.4 PR162.1
DDR_PG_CTRL_S: HR12.1 HU1.2 U1.AV61
DE_11: R328.1 U13.3
DE_12: R325.2 R330.1 U13.16
DE_21: R336.1 U14.3
DE_22: R333.2 R338.1 U14.16
DET_RIO#: C182.1 CON11.3 R145.2 U1.P2
DET_SPK_L#: CON10.13 R148.1 U1.T3
DIFFCLK_BIASREF: CKR2.1 U1.C26
DIMM0_VREF_DQ: C42.1 R42.1 U1.AR51
DIMM1_VREF_DQ: C45.2 R56.1 R60.2 R66.2 U1.AP51
DIMM1_VREF_DQ_R: C1194.1 C1195.1 DIMM1.1 R66.1
DIMM_VREF_CA: C43.1 C46.2 R43.2 R57.1 R59.2 R61.2 U1.AP49
DIMM_VREF_CA_R: C1192.1 C1193.1 DIMM1.126 R59.1
DISABLE_ME#: R88.2 R89.2 SR2.1 U1.AM3
DMIC_CLK: CON10.2 R250.1 VU2.2
DMIC_CLK_OB: R249.1 VU2.4
DMIC_CLK_Q: C103.1 CON6.8 R249.2 R250.2
DMIC_DATA: CON10.1 R247.1 R248.2
DMIC_DATA_OB: R248.1 VU1.4
DMIC_DATA_Q: C102.1 CON6.6 R247.2 VU1.2
DP_COMP: HR16.2 U1.D20
DP_DDI1_C_TX0: CONWIFI.34 S1C6.2
DP_DDI1_C_TX0#: CONWIFI.32 S1C5.2
DP_DDI1_C_TX1: CONWIFI.28 S1C4.2
DP_DDI1_C_TX1#: CONWIFI.26 S1C3.2
DP_DDI1_C_TX2: CONWIFI.27 S1C10.1
DP_DDI1_C_TX2#: CONWIFI.25 S1C9.1
DP_DDI1_C_TX3: CONWIFI.21 S1C8.1
DP_DDI1_C_TX3#: CONWIFI.19 S1C7.1
DP_DDI1_TX0: S1C6.1 U1.C55
DP_DDI1_TX0#: S1C5.1 U1.C54
DP_DDI1_TX1: S1C4.1 U1.C58
DP_DDI1_TX1#: S1C3.1 U1.B58
DP_DDI1_TX2: S1C10.2 U1.A55
DP_DDI1_TX2#: S1C9.2 U1.B55
DP_DDI1_TX3: S1C8.2 U1.B57
DP_DDI1_TX3#: S1C7.2 U1.A57
DQA_ZQ1: R30.1 U2.L8
DQA_ZQ2: R31.1 U3.L8
DQA_ZQ3: R32.1 U4.L8
DQA_ZQ4: R33.1 U5.L8
DQA_ZQ5: R34.1 U2.L9
DQA_ZQ6: R35.1 U3.L9
DQA_ZQ7: R36.1 U4.L9
DQA_ZQ8: R37.1 U5.L9
DSWODVREN: PR2.2 U1.AW7
DTM_AC_OFF: PQ13.2 PQ13.5 PR77.1 U10.97
EC_RST#: C88.1 D8.3 R229.2 SC5.1 U10.14
EC_XIN: C80.1 R210.1 R212.1 R216.1 U10.128
EC_XOUT: R210.2 R211.1 U10.2
EDID_CLK: C128.1 P2.3 R136.2 U6.49
EDID_DATA: C129.1 P2.4 R138.2 U6.50
EDP_AUXN: C65.2 R125.1 R128.2 U1.A45
EDP_AUXN_C: C65.1 U6.60
EDP_AUXP: C66.2 R124.1 R127.2 U1.B45
EDP_AUXP_C: C66.1 U6.61
EDP_DISP_UTIL: HT95.1 U1.A43
EDP_HPD: R95.1 R99.1 U1.D6 U6.58
EDP_TXN0: C62.1 U1.C45
EDP_TXN0_C: C62.2 U6.4
EDP_TXN1: C64.1 U1.A47
EDP_TXN1_C: C64.2 U6.7
EDP_TXP0: C61.1 U1.B46
EDP_TXP0_C: C61.2 U6.3
EDP_TXP1: C63.1 U1.B47
EDP_TXP1_C: C63.2 U6.6
EN_RXD1: T35.1 U13.5
EN_RXD2: T37.1 U14.5
EQ_11: R327.1 U13.2
EQ_12: R324.2 R329.1 U13.17
EQ_21: R335.1 U14.2
EQ_22: R332.2 R337.1 U14.17
EXT_SCI#: D7.1 RN8.1 U1.AN2
EXT_SMI#: D6.1 SR4.2 U1.AG5
FAN0_PWM: Q20.2 R277.1 U10.32
FAN0_PWM_Q: CON7.2 Q20.3 R276.2 R277.2
FAN0_TACH: C116.1 D13.1 R278.2 U10.47
FF_ON: Q5.5 R235.1 U16.9
FF_ON_D: Q5.2 Q5.3 R234.2
FF_ON_O: CON3.P11 Q5.6 R232.2 R235.2 T29.1
FF_ON_PCH: SR9208.2 U1.P3 U16.11
FORCE_OFF#: D8.2 Q3.3 Q3.6 Q9200.3 T9206.1 U12.4
GPIO2: SR50.2 U1.J3
GPIO3: SR88.2 U1.J4
GPIO38: SR9209.2 U1.L2
GPIO39: SR9210.2 U1.N5
GPIO66: SR89.1 SR90.2 U1.D3
GPIO86: SR86.1 SR87.2 U1.L8
GPIO_R: R60358.2 U6.16
GYRO_INT1: U20.30 UA3.7
H_CPU_SVIDALRT#: HR24.2 U1.L62
H_CPUPWRGD_R: HR5.2 HT2.1 U1.C61
H_LP4+: CN1.3 D11.1 L6.1 RN7.3
H_LP4-: CN1.4 D12.1 L6.4 RN7.1
H_PECI_EC: C201.1 R114.1 U10.117
H_PROCHOT#: HQ1.3 HR2.2 HR3.2 HR4.1 PC219.1
H_PROCHOT#_D: HR4.2 U1.K63
H_THRMTRIP#: Q4.2 SR15.2 SR18.2
HDA_BCLK_R: AR1.1 U1.AW8
HDA_RST#_R: AR3.1 U1.AU8
HDA_SDO_R: AR4.1 Q1.3 U1.AU11
HDA_SYNC_R: AR2.1 U1.AV11
HIERR#_G: CR8.1 Q12.3 R243.2
HOMEKEY_BTN#: CON9.3 D2.2 R173.2 T53.1 T54.1 U10.70
HOMEKEY_BTN#_R: D2.1 R119.2 U1.AU2
HOMEKEY_DET#: CON9.2 R146.2 U1.L6
HOMEKEY_LED_ON#: Q39.1 R349.2 U10.20
HOMEKEY_LED_ON#_Q: CON9.7 Q39.3 R349.1
HOST_ALERT1#_R: SR28.2 U1.AD6
HSIO_PWR_CNTL: PQ5.2 PR53.2 PR54.1 U1.Y2
I2C1_SCL_IO: R258.1 R356.2 R60370.2 T72.1 U17.4 U19.4 U20.13 UA3.2
I2C1_SCL_IO_G: Q15.1 R254.2
I2C1_SCL_IO_R: C187.1 CON11.4 R355.2 R356.1
I2C1_SDA_IO: R260.1 R357.2 R60371.2 T71.1 U17.6 U19.6 U20.12 UA3.3
I2C1_SDA_IO_G: Q16.1 R252.2
I2C1_SDA_IO_R: C186.1 CON11.5 R354.2 R357.1
INT_PIRQA#: RN4.4 U1.U6
INT_PIRQB#: RN4.6 U1.P4
INT_PIRQC#: RN4.8 U1.N4
INT_PIRQD#: RN4.2 U1.N2
JTCKC: R430.1 U20.20
JTMSC: R428.1 U20.26
KSI0: CON2.8 U10.58
KSI1: CON2.7 U10.59
KSI2: CON2.6 U10.60
KSI3: CON2.5 U10.61
KSI4: CON2.4 U10.62
KSI5: CON2.3 U10.63
KSI6: CON2.2 U10.64
KSI7: CON2.1 U10.65
KSO0: CON2.26 U10.36
KSO1: CON2.25 U10.37
KSO2: CON2.24 U10.38
KSO3: CON2.23 U10.39
KSO4: CON2.22 U10.40
KSO5: CON2.21 U10.41
KSO6: CON2.20 U10.42
KSO7: CON2.19 U10.43
KSO8: CON2.18 U10.44
KSO9: CON2.17 U10.45
KSO10: CON2.16 U10.46
KSO11: CON2.15 U10.51
KSO12: CON2.14 U10.52
KSO13: CON2.13 U10.53
KSO14: CON2.12 U10.54
KSO15: CON2.11 U10.55
KSO16: CON2.10 T27.1
KSO17: CON2.9 T28.1
L_BKLT_CTRL_PCH: GR39.1 U1.B8
L_VDDEN_PCH: U1.C6 U10.79
LAD0: R166.2 R178.1 U1.AU14
LAD0_EC: CON5.2 R178.2 U10.10
LAD0_TPM: R166.1 U9.26
LAD1: R167.2 R182.1 U1.AW12
LAD1_EC: CON5.4 R182.2 U10.9
LAD1_TPM: R167.1 U9.23
LAD2: R169.2 R183.1 U1.AY12
LAD2_EC: CON5.6 R183.2 U10.8
LAD2_TPM: R169.1 U9.20
LAD3: R170.2 R185.1 U1.AW11
LAD3_EC: CON5.8 R185.2 U10.7
LAD3_TPM: R170.1 U9.17
LCD_BACKOFF_EC#: R293.2 U10.57
LCD_BKEN_PCH: U1.A9 U10.48
LCD_BL_PWM: CB7.1 R288.2 U10.30
LCD_BL_PWM_C: P2.35 R286.1 R288.1 R289.1 VU3.4
LCD_VDD_EN_EC: R297.2 U10.78
LPC_FRAME#: R168.2 R186.1 U1.AV12
LPC_FRAME#_EC: CON5.10 R186.2 U10.6
LPC_FRAME#_TPM: R168.1 U9.22
LRESET#: R171.1 U9.16
LVDS_DET_CBL#: P2.7 R426.2 U1.J1
LVDS_L0N_NB: P2.21 U6.19
LVDS_L0P_NB: P2.20 U6.20
LVDS_L1N_NB: P2.18 U6.21
LVDS_L1P_NB: P2.17 U6.22
LVDS_L2N_NB: P2.15 U6.23
LVDS_L2P_NB: P2.14 U6.24
LVDS_LCDEN_B: Q23.1 R302.2
LVDS_LCDEN_C: Q22.1 Q23.3 R298.2
LVDS_LCLKN_NB: P2.9 U6.26
LVDS_LCLKP_NB: P2.8 U6.27
LVDS_U0N_NB: P2.30 U6.35
LVDS_U0P_NB: P2.29 U6.36
LVDS_U1N_NB: P2.27 U6.37
LVDS_U1P_NB: P2.26 U6.38
LVDS_U2N_NB: P2.24 U6.40
LVDS_U2P_NB: P2.23 U6.41
LVDS_UCLKN_NB: C131.1 P2.12 U6.42
LVDS_UCLKP_NB: C130.1 P2.11 U6.43
M_A_B_DIMM_ODT: HQ2.2 HR14.1 HR15.1
M_CHA_BA0: R1.1 U1.AU35 U2.M2 U3.M2 U4.M2 U5.M2
M_CHA_BA1: R2.1 U1.AV35 U2.N8 U3.N8 U4.N8 U5.N8
M_CHA_BA2: R3.1 U1.AY41 U2.M3 U3.M3 U4.M3 U5.M3
M_CHA_CAS#: R7.1 U1.AU34 U2.K3 U3.K3 U4.K3 U5.K3
M_CHA_CKE0: R5.1 U1.AU43 U2.K9 U3.K9 U4.K9 U5.K9
M_CHA_CKE1: R25.1 U1.AW43 U2.J9 U3.J9 U4.J9 U5.J9
M_CHA_CLK0: R27.1 U1.AV37 U2.J7 U3.J7 U4.J7 U5.J7
M_CHA_CLK0#: R28.1 U1.AU37 U2.K7 U3.K7 U4.K7 U5.K7
M_CHA_CS#0: R4.1 U1.AP33 U2.L2 U3.L2 U4.L2 U5.L2
M_CHA_CS#1: R26.1 U1.AR32 U2.L1 U3.L1 U4.L1 U5.L1
M_CHA_DQ0: U1.AH63 U2.H3
M_CHA_DQ1: U1.AH62 U2.G2
M_CHA_DQ2: U1.AK63 U2.F8
M_CHA_DQ3: U1.AK62 U2.F7
M_CHA_DQ4: U1.AH61 U2.F2
M_CHA_DQ5: U1.AH60 U2.H8
M_CHA_DQ6: U1.AK61 U2.H7
M_CHA_DQ7: U1.AK60 U2.E3
M_CHA_DQ8: U1.AM63 U2.A3
M_CHA_DQ9: U1.AM62 U2.A2
M_CHA_DQ10: U1.AP63 U2.D7
M_CHA_DQ11: U1.AP62 U2.A7
M_CHA_DQ12: U1.AM61 U2.C3
M_CHA_DQ13: U1.AM60 U2.C2
M_CHA_DQ14: U1.AP61 U2.C8
M_CHA_DQ15: U1.AP60 U2.B8
M_CHA_DQ16: U1.AP58 U3.E3
M_CHA_DQ17: U1.AR58 U3.H3
M_CHA_DQ18: U1.AM57 U3.F7
M_CHA_DQ19: U1.AK57 U3.F8
M_CHA_DQ20: U1.AL58 U3.F2
M_CHA_DQ21: U1.AK58 U3.G2
M_CHA_DQ22: U1.AR57 U3.H7
M_CHA_DQ23: U1.AN57 U3.H8
M_CHA_DQ24: U1.AP55 U3.A7
M_CHA_DQ25: U1.AR55 U3.B8
M_CHA_DQ26: U1.AM54 U3.C2
M_CHA_DQ27: U1.AK54 U3.A2
M_CHA_DQ28: U1.AL55 U3.A3
M_CHA_DQ29: U1.AK55 U3.C3
M_CHA_DQ30: U1.AR54 U3.D7
M_CHA_DQ31: U1.AN54 U3.C8
M_CHA_DQ32: U1.AY58 U4.F2
M_CHA_DQ33: U1.AW58 U4.G2
M_CHA_DQ34: U1.AY56 U4.F8
M_CHA_DQ35: U1.AW56 U4.F7
M_CHA_DQ36: U1.AV58 U4.H7
M_CHA_DQ37: U1.AU58 U4.H3
M_CHA_DQ38: U1.AV56 U4.H8
M_CHA_DQ39: U1.AU56 U4.E3
M_CHA_DQ40: U1.AY54 U4.A2
M_CHA_DQ41: U1.AW54 U4.C3
M_CHA_DQ42: U1.AY52 U4.C8
M_CHA_DQ43: U1.AW52 U4.D7
M_CHA_DQ44: U1.AV54 U4.C2
M_CHA_DQ45: U1.AU54 U4.A3
M_CHA_DQ46: U1.AV52 U4.A7
M_CHA_DQ47: U1.AU52 U4.B8
M_CHA_DQ48: U1.AK40 U5.B8
M_CHA_DQ49: U1.AK42 U5.C8
M_CHA_DQ50: U1.AM43 U5.C3
M_CHA_DQ51: U1.AM45 U5.A2
M_CHA_DQ52: U1.AK45 U5.A3
M_CHA_DQ53: U1.AK43 U5.C2
M_CHA_DQ54: U1.AM40 U5.A7
M_CHA_DQ55: U1.AM42 U5.D7
M_CHA_DQ56: U1.AM46 U5.H8
M_CHA_DQ57: U1.AK46 U5.F8
M_CHA_DQ58: U1.AM49 U5.E3
M_CHA_DQ59: U1.AK49 U5.F2
M_CHA_DQ60: U1.AM48 U5.H7
M_CHA_DQ61: U1.AK48 U5.F7
M_CHA_DQ62: U1.AM51 U5.H3
M_CHA_DQ63: U1.AK51 U5.G2
M_CHA_DQS0: U1.AJ62 U2.F3
M_CHA_DQS0#: U1.AJ61 U2.G3
M_CHA_DQS1: U1.AN61 U2.C7
M_CHA_DQS1#: U1.AN62 U2.B7
M_CHA_DQS2: U1.AN58 U3.F3
M_CHA_DQS2#: U1.AM58 U3.G3
M_CHA_DQS3: U1.AN55 U3.C7
M_CHA_DQS3#: U1.AM55 U3.B7
M_CHA_DQS4: U1.AW57 U4.F3
M_CHA_DQS4#: U1.AV57 U4.G3
M_CHA_DQS5: U1.AW53 U4.C7
M_CHA_DQS5#: U1.AV53 U4.B7
M_CHA_DQS6: U1.AL42 U5.C7
M_CHA_DQS6#: U1.AL43 U5.B7
M_CHA_DQS7: U1.AL49 U5.F3
M_CHA_DQS7#: U1.AL48 U5.G3
M_CHA_MAA0: R9.1 U1.AU36 U2.N3 U3.N3 U4.N3 U5.N3
M_CHA_MAA1: R10.1 U1.AY37 U2.P7 U3.P7 U4.P7 U5.P7
M_CHA_MAA2: R11.1 U1.AR38 U2.P3 U3.P3 U4.P3 U5.P3
M_CHA_MAA3: R12.1 U1.AP36 U2.N2 U3.N2 U4.N2 U5.N2
M_CHA_MAA4: R13.1 U1.AU39 U2.P8 U3.P8 U4.P8 U5.P8
M_CHA_MAA5: R14.1 U1.AR36 U2.P2 U3.P2 U4.P2 U5.P2
M_CHA_MAA6: R15.1 U1.AV40 U2.R8 U3.R8 U4.R8 U5.R8
M_CHA_MAA7: R16.1 U1.AW39 U2.R2 U3.R2 U4.R2 U5.R2
M_CHA_MAA8: R17.1 U1.AY39 U2.T8 U3.T8 U4.T8 U5.T8
M_CHA_MAA9: R18.1 U1.AU40 U2.R3 U3.R3 U4.R3 U5.R3
M_CHA_MAA10: R19.1 U1.AP35 U2.L7 U3.L7 U4.L7 U5.L7
M_CHA_MAA11: R20.1 U1.AW41 U2.R7 U3.R7 U4.R7 U5.R7
M_CHA_MAA12: R21.1 U1.AU41 U2.N7 U3.N7 U4.N7 U5.N7
M_CHA_MAA13: R22.1 U1.AR35 U2.T3 U3.T3 U4.T3 U5.T3
M_CHA_MAA14: R23.1 U1.AV42 U2.T7 U3.T7 U4.T7 U5.T7
M_CHA_MAA15: R24.1 U1.AU42 U2.M7 U3.M7 U4.M7 U5.M7
M_CHA_ODT0: R29.1 U2.J1 U2.K1 U3.J1 U3.K1 U4.J1 U4.K1 U5.J1 U5.K1
M_CHA_RAS#: R6.1 U1.AY34 U2.J3 U3.J3 U4.J3 U5.J3
M_CHA_WE#: R8.1 U1.AW34 U2.L3 U3.L3 U4.L3 U5.L3
M_CHB_BA0: DIMM1.109 U1.AL35
M_CHB_BA1: DIMM1.108 U1.AM36
M_CHB_BA2: DIMM1.79 U1.AU49
M_CHB_CAS#: DIMM1.115 U1.AM33
M_CHB_CKE0: DIMM1.73 U1.AY49
M_CHB_CKE1: DIMM1.74 U1.AU50
M_CHB_CLK0: DIMM1.101 U1.AN38
M_CHB_CLK0#: DIMM1.103 U1.AM38
M_CHB_CLK1: DIMM1.102 U1.AL38
M_CHB_CLK1#: DIMM1.104 U1.AK38
M_CHB_CS#0: DIMM1.114 U1.AM32
M_CHB_CS#1: DIMM1.121 U1.AK32
M_CHB_DQ0: DIMM1.6 U1.AY31
M_CHB_DQ1: DIMM1.4 U1.AW31
M_CHB_DQ2: DIMM1.16 U1.AY29
M_CHB_DQ3: DIMM1.18 U1.AW29
M_CHB_DQ4: DIMM1.7 U1.AV31
M_CHB_DQ5: DIMM1.5 U1.AU31
M_CHB_DQ6: DIMM1.15 U1.AV29
M_CHB_DQ7: DIMM1.17 U1.AU29
M_CHB_DQ8: DIMM1.24 U1.AY27
M_CHB_DQ9: DIMM1.22 U1.AW27
M_CHB_DQ10: DIMM1.35 U1.AY25
M_CHB_DQ11: DIMM1.34 U1.AW25
M_CHB_DQ12: DIMM1.23 U1.AV27
M_CHB_DQ13: DIMM1.21 U1.AU27
M_CHB_DQ14: DIMM1.33 U1.AV25
M_CHB_DQ15: DIMM1.36 U1.AU25
M_CHB_DQ16: DIMM1.42 U1.AM29
M_CHB_DQ17: DIMM1.40 U1.AK29
M_CHB_DQ18: DIMM1.41 U1.AL28
M_CHB_DQ19: DIMM1.39 U1.AK28
M_CHB_DQ20: DIMM1.52 U1.AR29
M_CHB_DQ21: DIMM1.53 U1.AN29
M_CHB_DQ22: DIMM1.50 U1.AR28
M_CHB_DQ23: DIMM1.51 U1.AP28
M_CHB_DQ24: DIMM1.69 U1.AN26
M_CHB_DQ25: DIMM1.70 U1.AR26
M_CHB_DQ26: DIMM1.67 U1.AR25
M_CHB_DQ27: DIMM1.59 U1.AP25
M_CHB_DQ28: DIMM1.56 U1.AK26
M_CHB_DQ29: DIMM1.68 U1.AM26
M_CHB_DQ30: DIMM1.57 U1.AK25
M_CHB_DQ31: DIMM1.58 U1.AL25
M_CHB_DQ32: DIMM1.129 U1.AY23
M_CHB_DQ33: DIMM1.131 U1.AW23
M_CHB_DQ34: DIMM1.143 U1.AY21
M_CHB_DQ35: DIMM1.142 U1.AW21
M_CHB_DQ36: DIMM1.130 U1.AV23
M_CHB_DQ37: DIMM1.132 U1.AU23
M_CHB_DQ38: DIMM1.140 U1.AV21
M_CHB_DQ39: DIMM1.141 U1.AU21
M_CHB_DQ40: DIMM1.147 U1.AY19
M_CHB_DQ41: DIMM1.149 U1.AW19
M_CHB_DQ42: DIMM1.159 U1.AY17
M_CHB_DQ43: DIMM1.157 U1.AW17
M_CHB_DQ44: DIMM1.146 U1.AV19
M_CHB_DQ45: DIMM1.148 U1.AU19
M_CHB_DQ46: DIMM1.158 U1.AV17
M_CHB_DQ47: DIMM1.160 U1.AU17
M_CHB_DQ48: DIMM1.177 U1.AR21
M_CHB_DQ49: DIMM1.166 U1.AR22
M_CHB_DQ50: DIMM1.174 U1.AL21
M_CHB_DQ51: DIMM1.163 U1.AM22
M_CHB_DQ52: DIMM1.164 U1.AN22
M_CHB_DQ53: DIMM1.175 U1.AP21
M_CHB_DQ54: DIMM1.176 U1.AK21
M_CHB_DQ55: DIMM1.165 U1.AK22
M_CHB_DQ56: DIMM1.181 U1.AN20
M_CHB_DQ57: DIMM1.183 U1.AR20
M_CHB_DQ58: DIMM1.193 U1.AK18
M_CHB_DQ59: DIMM1.191 U1.AL18
M_CHB_DQ60: DIMM1.180 U1.AK20
M_CHB_DQ61: DIMM1.182 U1.AM20
M_CHB_DQ62: DIMM1.192 U1.AR18
M_CHB_DQ63: DIMM1.194 U1.AP18
M_CHB_DQS0: DIMM1.12 U1.AV30
M_CHB_DQS0#: DIMM1.10 U1.AW30
M_CHB_DQS1: DIMM1.29 U1.AW26
M_CHB_DQS1#: DIMM1.27 U1.AV26
M_CHB_DQS2: DIMM1.47 U1.AM28
M_CHB_DQS2#: DIMM1.45 U1.AN28
M_CHB_DQS3: DIMM1.64 U1.AM25
M_CHB_DQS3#: DIMM1.62 U1.AN25
M_CHB_DQS4: DIMM1.137 U1.AV22
M_CHB_DQS4#: DIMM1.135 U1.AW22
M_CHB_DQS5: DIMM1.154 U1.AW18
M_CHB_DQS5#: DIMM1.152 U1.AV18
M_CHB_DQS6: DIMM1.171 U1.AM21
M_CHB_DQS6#: DIMM1.169 U1.AN21
M_CHB_DQS7: DIMM1.188 U1.AM18
M_CHB_DQS7#: DIMM1.186 U1.AN18
M_CHB_MAA0: DIMM1.98 U1.AP40
M_CHB_MAA1: DIMM1.97 U1.AR40
M_CHB_MAA2: DIMM1.96 U1.AP42
M_CHB_MAA3: DIMM1.95 U1.AR42
M_CHB_MAA4: DIMM1.92 U1.AR45
M_CHB_MAA5: DIMM1.91 U1.AP45
M_CHB_MAA6: DIMM1.90 U1.AW46
M_CHB_MAA7: DIMM1.86 U1.AY46
M_CHB_MAA8: DIMM1.89 U1.AY47
M_CHB_MAA9: DIMM1.85 U1.AU46
M_CHB_MAA10: DIMM1.107 U1.AK36
M_CHB_MAA11: DIMM1.84 U1.AV47
M_CHB_MAA12: DIMM1.83 U1.AU47
M_CHB_MAA13: DIMM1.119 U1.AK33
M_CHB_MAA14: DIMM1.80 U1.AR46
M_CHB_MAA15: DIMM1.78 U1.AP46
M_CHB_ODT0: DIMM1.116 HR15.2
M_CHB_ODT1: DIMM1.120 HR14.2
M_CHB_RAS#: DIMM1.110 U1.AM35
M_CHB_WE#: DIMM1.113 U1.AK35
MAG_DRDY_IO: R360.2 U17.7 U20.32
MAG_DRDY_IO_R: C185.1 CON11.8 R360.1
MEM_ID0: R92.2 R96.1 U1.L3
MEM_ID1: R93.2 R97.1 U1.R5
MEM_ID2: R94.2 R98.1 U1.L4
MSATA_DISABLE: CONSATA.8 SR16.2 SR21.1 SR85.2
MSATA_RST#: CONSATA.50 U10.104
NGFF_PCIE_WAKE#: R175.2 R184.1 R307.1
NGFF_PCIE_WAKE#_EC: R184.2 U10.56
OC0#: CON10.16 U1.AL3
OC1#: CON10.17 U1.AT1
OC2#: C181.1 CON11.12 U1.AH2
OC3#: R109.2 U1.AV3
OS_11: R323.2 U13.4
OS_12: R326.2 U13.15
OS_21: R331.2 U14.4
OS_22: R334.2 U14.15
PANEL_BIST_ON: U10.77 VU3.1 VU4.1 VU5.1
PANEL_BIST_ON_R: P2.6 R285.1 VR2.1
PASSWORD_CLR: R78.1 SR9.2 U1.AM4
PASSWORD_CLR_R: E2.2 R78.2
PCB_ID0_EC: R191.2 R455.2 U10.119
PCB_ID1_EC: R190.2 R456.2 U10.123
PCB_ID2_EC: R203.2 R457.2 T25.1 U10.87
PCH_DPWROK: PR13.1 R192.2 U1.AV5
PCH_GPIO26_R: Q1.1 SR2.2
PCH_GPIO26_R_C: Q1.2 SR1.2
PCH_INTVRMEN: R72.1 R75.2 U1.AV7
PCH_JTAG_TCK: GR17.2 GR18.2 GR37.1 U1.AE62
PCH_JTAG_TDI: GR20.2 GR28.2 GR32.2 GR38.1 U1.AD61 XDP1.56
PCH_JTAG_TDO: GR16.1 GR21.1 GR29.2 GR33.2 GR35.1 U1.AE61
PCH_JTAG_TMS: GR30.2 GR34.2 GR36.1 GU1.9 U1.AD62 XDP1.58
PCH_JTAGX: GR19.2 GR23.2 GR31.2 U1.AE63
PCH_OPIRCOMP: SR19.1 U1.AW15
PCIE_RCOMP: SR10.2 U1.A27
PCIE_RXN3_WLAN: CONWIFI.43 U1.G11
PCIE_RXN4_WLAN: CONWIFI.67 U1.F13
PCIE_RXN6_CR: CON10.41 U1.F10
PCIE_RXP3_WLAN: CONWIFI.41 U1.F11
PCIE_RXP4_WLAN: CONWIFI.65 U1.G13
PCIE_RXP6_CR: CON10.40 U1.E10
PCIE_TXN3_WLAN: SC9.2 U1.C29
PCIE_TXN3_WLAN_S: CONWIFI.37 SC9.1
PCIE_TXN4_WLAN: SC11.2 U1.B29
PCIE_TXN4_WLAN_S: CONWIFI.61 SC11.1
PCIE_TXN6_CR: CON10.38 U1.C23
PCIE_TXP3_WLAN: SC8.2 U1.B30
PCIE_TXP3_WLAN_S: CONWIFI.35 SC8.1
PCIE_TXP4_WLAN: SC10.2 U1.A29
PCIE_TXP4_WLAN_S: CONWIFI.59 SC10.1
PCIE_TXP6_CR: CON10.37 U1.C22
PCIE_WAKE#: PR12.2 R205.2 R279.2 R60476.1 U1.AJ5
PCIE_WAKE#_EC: R205.1 U10.99
PECI_EC_LPCSB: R114.2 U1.N62
PLT_RST#: GR14.1 Q3.2 Q3.5 R171.2 R60472.2 R60475.2 SC4.1 U1.AG7 U10.22
PLT_RST#_R: CONWIFI.52 R60472.1 R60473.1
PLTRST_WLAN#: PR233.2 R60473.2 R60474.2 U10.28
PM_APWROK_R: PR14.2 U1.AB5
PM_CLKRUN#: PR8.2 R172.2 U1.V5 U10.93
PM_CLKRUN#_R: R172.1 R440.1 U9.15
PM_PCH_PWROK_R: PR11.2 U1.AY7
PM_PWRBTN#: PR26.1 U10.76
PM_PWRBTN#_XDP: GR10.1 XDP1.41
PM_PWROK: PR11.1 PR14.1 PR16.1 Q14.1 R410.2 SC3.1 U10.124
PM_RSMRST#: PR18.1 R177.2 U1.AW6
PM_RSMRST#_R: R177.1 U10.112
PM_SYSRST#: GR15.1 PR7.2 PR216.1
PM_SYSRST#_R: PR216.2 U1.AC3
PM_THRMTRIP#: SR15.1 U1.D60
POGO_ID_VOL_D: Q34.1 Q35.3 R340.2
POGO_ID_VOL_G: Q35.1 R341.2 R342.1
POGO_IN_OC#: PQ9.3 R207.1 T59.1
POGO_IN_OC#_EC1: R207.2 U10.90
PQ24A_G: PQ9.2 PQ10.3 PR68.2
PRESSURE_INT1: U19.9 U20.31
PROC_OPI_COMP: HR43.1 U1.AY15
PWM_LED_A: C178.1 CON11.11 U10.25
PWM_LED_W: C179.1 CON11.10 U10.24
PWR_DEBUG: GR13.2 GR24.2 GR26.1 GR27.2 GU2.2
PWR_DEBUG_R: GR13.1 XDP1.45
PWR_SW: HQ3.1 R435.2 U10.106
PWR_SW#: GR12.2 R208.2 U10.125
PWR_SW#_R: D9201.1 R206.2 R208.1 R434.2
PWRBTN#: C180.1 CON11.9 D9201.3 R434.1 SW1.1 SW1.3
PWRSW_SHM: D9201.2 HQ3.3 PR226.2
PWRSW_SHM_R: C400.2 PQ34.1 PR226.1 R436.2
R_BIAS: C67.1 R132.2 U6.64
RCIN#: SR13.2 U1.V4 U10.4
RSVD31: HT57.1 U1.AT2
RSVD33: HT61.1 U1.AV44
RSVD34: HT62.1 U1.D15
RSVD35: HT65.1 U1.F22
RSVD36: HT67.1 U1.H22
RSVD38: HT55.1 U1.N23
RSVD39: HT56.1 U1.R23
RSVD40: HT58.1 U1.T23
RSVD41: HT60.1 U1.U10
RSVD42: HT63.1 U1.AL1
RSVD44: HT66.1 U1.AP7
RSVD45: HT68.1 U1.AU10
RSVD46: HT70.1 U1.AU15
RSVD47: HT71.1 U1.AW14
RSVD48: HT72.1 U1.AY14
RSVD49: HT40.1 U1.A5
RSVD50: HT42.1 U1.E1
RSVD51: HT44.1 U1.D1
RSVD52: HT45.1 U1.J20
RSVD53: HT46.1 U1.H18
RSVD54: HT21.1 U1.B43
RSVD55: HT29.1 U1.N60
RSVD56: HT32.1 U1.W23
RSVD57: HT33.1 U1.Y22
RSVD58: HT37.1 U1.AV62
RSVD59: HT39.1 U1.D58
RSVD60: HT41.1 U1.P20
RSVD61: HT43.1 U1.R20
RSVD_6: T4.1 U1.K21
RSVD_7: T5.1 U1.M21
RSVD_69: HT9.1 U1.P60
RSVD_70: HT10.1 U1.P61
RSVD_71: HT11.1 U1.N59
RSVD_72: HT12.1 U1.N61
RSVD_TP5: HT13.1 U1.AV63
RSVD_TP8: HT26.1 U1.L60
RSVD_TP9: HT19.1 U1.C62
RSVD_TP10: HT18.1 U1.C63
RSVD_TP11: HT17.1 U1.AU63
RSVD_TP55: HT23.1 U1.A51
RSVD_TP66: HT24.1 U1.B51
RSVL: R131.2 U6.11
RTC_RST#: C52.1 R76.1 R77.2 T1.1 U1.AU7
RTC_RST#_R: E2.10 R76.2
RTC_X1: C49.1 R70.1 U1.AW5 X1.1
RTC_X2: C50.1 R70.2 U1.AY5 X1.4
SATA2GP: SR51.2 SR59.1 U1.V6
SATA3GP: SR52.2 SR60.1 U1.AC1
SATA_COMP: SR7.1 U1.C12
SATA_RXN0: CX3.1 U1.J5
SATA_RXN0_C: C9218.2 CON3.S5
SATA_RXN0_C_DR: CX3.2 U21.4
SATA_RXN0_DR: C9218.1 U21.12
SATA_RXN1: C122.2 U1.J8
SATA_RXN1_C: C122.1 CONSATA.43
SATA_RXP0: CX4.1 U1.H5
SATA_RXP0_C: C9219.2 CON3.S6
SATA_RXP0_C_DR: CX4.2 U21.5
SATA_RXP0_DR: C9219.1 U21.11
SATA_RXP1: C121.2 U1.H8
SATA_RXP1_C: C121.1 CONSATA.41
SATA_STRAP: PQ7.3 PQ8.3 SR3.2 SR61.1 SR62.2 SR63.1 U1.U1 U1.V1
SATA_TXN0: C196.1 U1.B15
SATA_TXN0_C: C9217.2 CON3.S3
SATA_TXN0_C_DR: C196.2 U21.2
SATA_TXN0_DR: C9217.1 U21.14
SATA_TXN1: C123.2 U1.A17
SATA_TXN1_C: C123.1 CONSATA.47
SATA_TXP0: C197.1 U1.A15
SATA_TXP0_C: C420.2 CON3.S2
SATA_TXP0_C_DR: C197.2 U21.1
SATA_TXP0_DR: C420.1 U21.15
SATA_TXP1: C124.2 U1.B17
SATA_TXP1_C: C124.1 CONSATA.49
SATALED#: SR8.1 U1.U3
SCE#: R213.1 R219.2 U11.1
SCE#_EC: R213.2 U10.101
SCK: R214.1 U11.6
SCK_EC: R214.2 U10.105
SCL_3A: RN1.2 SQ1.6 SR73.2 U1.AP2
SDA_3A: RN1.4 SQ1.3 SR74.2 U1.AH1
SENSOR1: C87.1 PR57.1 PRT3.1 U10.66
SENSOR2: C83.1 PR55.1 PRT1.1 U10.71
SENSOR3: C84.1 PR56.1 PRT2.1 U10.73
SERIRQ: R110.2 R165.2 R188.1 SR14.2
SERIRQ_EC: R188.2 U10.5
SERIRQ_PCH: R110.1 U1.T4
SERIRQ_TPM: R165.1 U9.27
SH_RST#_EC: R60369.1 U10.109
SH_RST#_IO: R60368.1 SR36.2 SR70.2 U1.AK4
SH_WAKE_IO: R429.2 SR35.2 U1.AB6
SH_WAKE_IO_R: R429.1 U20.6
SHIPPINGMODE: Q38.1 U10.18
SI: R215.1 U11.5
SI_EC: R215.2 U10.102
SLP_LAN#: PR20.2 U1.AJ7
SLP_S3#: PR22.2 Q11.1 R222.1 U10.107
SLP_S3#_R: PR22.1 U1.AT4
SLP_S4#: PR21.2 Q10.1 R223.1 U10.21
SLP_S4#_R: PR21.1 U1.AJ6
SLP_S5#: Q9.1 Q26.1 U1.AP5
SLP_SUS#: PR24.2 Q8.1 SC6.1 U10.96
SLP_SUS#_R: PR24.1 U1.AP4
SLP_WLAN#: PR220.1 Q25.1 SR97.2 U10.81
SLP_WLAN_R: PR220.2 U1.AM5
SM_DRAMRST#: R39.1 U1.AV15
SM_INTRUDER#: R73.2 T2.1 U1.AU6
SM_RCOMP_0: HR7.1 U1.AU60
SM_RCOMP_1: HR8.1 U1.AV60
SM_RCOMP_2: HR9.1 U1.AU61
SMB0_CLK_C: C160.1 CON8.3 D22.1 L9.1 T44.1
SMB0_DAT_C: C159.1 CON8.4 D21.1 L10.1 T43.1
SMB_CLK_M_MINI0: CONWIFI.60 D14.1 R305.2 R309.1
SMB_CLK_M_MSATA0: CONSATA.58 R281.1
SMB_CLK_S: DIMM1.202 R281.2 R309.2 SQ1.1 SR71.1 SR73.1 U16.4 XDP1.53
SMB_DAT_S: DIMM1.200 R280.2 R308.2 SQ1.4 SR72.1 SR74.1 U16.6 XDP1.51
SMB_DATA_M_MINI0: CONWIFI.58 R308.1
SMB_DATA_M_MSATA0: CONSATA.56 R280.1
SML0_CLK: R406.1 U1.AN1
SML0_CLK_EC: PR88.2 Q40.3 R195.2 U10.110
SML0_CLK_EC_Q: CON9.4 Q40.4 R352.2
SML0_DAT: R407.1 U1.AK1
SML0_DATA_EC: PR89.2 Q40.6 R196.2 U10.111
SML0_DATA_EC_Q: CON9.5 Q40.1 R351.2
SML0ALERT#: R405.2 U1.AL2
SML1_CLK: RN3.2 SQ2.6 SR75.1 U1.AU3
SML1_CLK_EC: Q15.2 R135.2 R197.2 R226.2 R253.2 R259.1 SQ2.1 SR75.2 U6.51 U10.115 U12.8
SML1_CLK_EC_Q: CON6.9 Q15.3 R256.2 R259.2 R260.2
SML1_DAT: RN3.4 SQ2.3 SR76.1 U1.AH3
SML1_DATA_EC: Q16.2 R137.2 R198.2 R227.2 R251.2 R257.1 SQ2.4 SR76.2 U6.52 U10.116 U12.7
SML1_DATA_EC_Q: CON6.10 Q16.3 R255.2 R257.2 R258.2
SML1ALERT#: RN8.3 U1.AU4
SML2_CLK_EC: L9.2 R193.2 U10.94
SML2_DATA_EC: L10.2 R194.2 U10.95
SO: U10.103 U11.2
SPI1_CLK: F3J1.4 F3R10.1 F3U1.6
SPI1_CS#0: F3J1.1 F3R14.2 F3U1.1 Q9202.3
SPI1_HOLD#: F3R3.2 F3R8.1 F3U1.7
SPI1_MISO: F3J1.7 F3R7.2 F3U1.2
SPI1_MOSI: F3J1.5 F3R11.1 F3U1.5
SPI_CLK: F3R10.2 U1.AA3
SPI_CS#0: F3J1.6 Q9202.2 U1.Y7
SPI_HOLD#: R221.2 U11.7
SPI_HOLD#_IO3: F3R8.2 U1.AF1
SPI_MISO: F3R7.1 U1.AA4
SPI_MOSI: F3R11.2 U1.AA2
SPI_WP#: R220.2 U11.3
SPI_WP_IO2: F3R9.1 U1.Y6
SPK_R_N_B: CON10.12 CON11.18
SPK_R_P_B: CON10.11 CON11.17
SPKR: CON10.32 SR27.2 U1.V2
SRTC_RST#: C51.1 R74.2 T3.1 U1.AV6
SUS_PWR_ACK_R: PR3.1 R91.2 U1.AV4
SUS_PWRGD: PR144.2 PU6.7 R60465.1 U10.67
SUS_STAT#: PR15.2 R164.2 U9.28
SUS_STAT#_R: PR15.1 U1.AG4
SUSACK#_R: PR3.2 U1.AK2
SUSB_EC#: D9200.2 PC177.1 PQ31.2 PR163.1 PR180.1 PR200.1 PU9.3 Q28.1 R224.1 R9204.1 U10.83
SUSB_ON#: Q27.2 Q27.5 Q28.3 Q29.2 Q29.5 Q30.2 Q30.5 R314.2
SUSB_POWER_G_B: PQ31.4 PR195.1 PR198.1 PR207.1
SUSC_EC#: PQ32.2 PR168.1 Q32.1 R225.1 U10.82
SUSC_ON#: Q31.2 Q31.5 Q32.3 Q33.1 R320.2
SUSCLK: CONSATA.68 CONWIFI.50 PR221.2 SC1.1
SUSCLK_GPIO62: PR221.1 U1.AE6
SUSWARN#: R91.1 U10.108
SYS_PRES#: CON8.6 Q38.3 R347.2 R348.1
SYS_PWROK: GR4.2 PR10.1 R187.2 SC2.1 XDP1.47
SYS_PWROK_R: PR10.2 U1.AG2
TD_IREF: HR45.2 U1.B12
TESTLOW1: CKRN1.3 U1.C35
TESTLOW2: CKRN1.1 U1.C34
TESTLOW3: CKRN2.1 U1.AK8
TESTLOW4: CKRN2.3 U1.AL8
THRO_CPU: HR6.1 R176.1 R181.2
TOUCH_DET_CBL#: CN1.1 D10.1 R425.2 U1.K3
TOUCH_ON#: Q19.1 U10.33
TOUCH_ON#_D: C114.1 Q19.3 R275.2 T33.1
TP_A6: T70.1 U1.A6
TP_A49: HT91.1 U1.A49
TP_A53: HT87.1 U1.A53
TP_AB21: ST3.1 U1.AB21
TP_AC20: PT4.1 U1.AC20
TP_AD2: T63.1 U1.AD2
TP_AD4: T8.1 U1.AD4
TP_AF2: T62.1 U1.AF2
TP_AF3: H19.1 U1.AF3
TP_AF20: ST4.1 U1.AF20
TP_AL11: AT6.1 U1.AL11
TP_AV10: AT3.1 U1.AV10
TP_AW10: AT2.1 U1.AW10
TP_AY8: AT4.1 U1.AY8
TP_B9: T65.1 U1.B9
TP_B49: HT92.1 U1.B49
TP_B50: HT86.1 U1.B50
TP_B54: HT84.1 U1.B54
TP_C46: HT90.1 U1.C46
TP_C47: HT89.1 U1.C47
TP_C49: HT85.1 U1.C49
TP_C50: HT82.1 U1.C50
TP_C51: HT81.1 U1.C51
TP_C53: HT83.1 U1.C53
TP_D61: HT1.1 U1.D61
TP_DC_TEST_A4: HT47.1 U1.A4
TP_DC_TEST_A60: HT49.1 U1.A60
TP_DC_TEST_A62: HT51.1 U1.A62
TP_DC_TEST_AV1: HT52.1 U1.AV1
TP_DC_TEST_AW1: HT53.1 U1.AW1
TP_DC_TEST_AW63: HT54.1 U1.AW63
TP_DC_TEST_AY60: HT48.1 U1.AY60
TP_DC_TEST_B2: HT50.1 U1.B2
TP_E2: ST27.1 U1.E2
TP_E13: ST2.1 U1.E13
TP_E15: ST1.1 U1.E15
TP_F1: ST22.1 U1.F1
TP_F2: ST19.1 U1.F2
TP_F3: ST20.1 U1.F3
TP_F4: ST24.1 U1.F4
TP_G2: ST28.1 U1.G2
TP_G4: ST21.1 U1.G4
TP_GPG2: HT99.1 U10.100
TP_H61: HT3.1 U1.H61
TP_H62: HT4.1 U1.H62
TP_H63: HT6.1 U1.H63
TP_J61: HT8.1 U1.J61
TP_K2: ST16.1 U1.K2
TP_K4: ST18.1 U1.K4
TP_K18: PT6.1 U1.K18
TP_K59: HT5.1 U1.K59
TP_K60: HT7.1 U1.K60
TP_L1: T10.1 U1.L1
TP_L5: ST14.1 U1.L5
TP_L11: AT9.1 U1.L11
TP_M20: PT7.1 U1.M20
TP_N7: ST15.1 U1.N7
TP_SMCLK2: HT96.1 U20.2
TP_SMDAT2: HT97.1 U20.3
TP_U7: T9.1 U1.U7
TP_V21: PT8.1 U1.V21
TP_Y20: PT2.1 U1.Y20
TPM_3P3V_R: CB5.1 CB6.1 R60471.2 U9.5
TPM_GP68: R144.2 U9.6
TS1#: L11.2 PC54.1 PQ10.5 PR67.2
TS1#_C: C161.1 CON8.5 D20.1 L11.1 T45.1
USB3_RX_N2_OUT: CON10.55 U14.20
USB3_RX_N3_OUT: CON10.52 U13.20
USB3_RX_P2_OUT: CON10.56 U14.19
USB3_RX_P3_OUT: CON10.53 U13.19
USB3_RXN0: SC23.1 U1.G20
USB3_RXN0_IN: SC23.2 U14.11
USB3_RXN1: SC17.2 U1.E18
USB3_RXN1_IN: SC17.1 U13.11
USB3_RXP0: SC24.1 U1.H20
USB3_RXP0_IN: SC24.2 U14.12
USB3_RXP1: SC18.2 U1.F18
USB3_RXP1_IN: SC18.1 U13.12
USB3_TX_N2_OUT: CON10.59 SC20.2
USB3_TX_N3_OUT: CON10.49 SC14.2
USB3_TX_P2_OUT: CON10.58 SC22.2
USB3_TX_P3_OUT: CON10.50 SC16.2
USB3_TXN0: SC19.2 U1.C33
USB3_TXN0_IN: SC19.1 U14.8
USB3_TXN0_OUT_C: SC20.1 U14.23
USB3_TXN1: SC13.1 U1.B33
USB3_TXN1_IN: SC13.2 U13.8
USB3_TXN1_OUT_C: SC14.1 U13.23
USB3_TXP0: SC21.2 U1.B34
USB3_TXP0_IN: SC21.1 U14.9
USB3_TXP0_OUT_C: SC22.1 U14.22
USB3_TXP1: SC15.1 U1.A33
USB3_TXP1_IN: SC15.2 U13.9
USB3_TXP1_OUT_C: SC16.1 U13.22
USB_BIAS: R108.1 U1.AJ10 U1.AJ11
USB_PN0: CON10.6 U1.AN8
USB_PN1: CON10.8 U1.AR7
USB_PN2: L5.3 RN6.3 U1.AR8
USB_PN3: L6.3 RN7.2 U1.AR10
USB_PN4: CON11.1 U1.AM15
USB_PN5: U1.AM13 U20.37
USB_PN6: CONWIFI.5 U1.AP11
USB_PN7: CONSATA.9 U1.AR13
USB_PP0: CON10.7 U1.AM8
USB_PP1: CON10.9 U1.AT7
USB_PP2: L5.2 RN6.1 U1.AP8
USB_PP3: L6.2 RN7.4 U1.AT10
USB_PP4: CON11.2 U1.AL15
USB_PP5: R431.1 U1.AN13 U20.38
USB_PP6: CONWIFI.3 U1.AN11
USB_PP7: CONSATA.7 U1.AP13
USBP10+: CON6.2 L5.1 RN6.2
USBP10-: CON6.3 L5.4 RN6.4
V_DOWN: CON10.15 R204.2 U10.88
V_LCD_C: Q22.3 R299.2
V_LCD_G: C146.1 Q21.1 R296.2 R299.1
V_UP: CON10.14 D4.2 R200.2 U10.89
VB+: C98.1 CON4.1 D9.2 Q6.3 ST8.1 T30.1 T31.1
VIBRATER_DET_CBL#: CON4.3 R427.2 U1.R6
VIBRATOR_ON#: Q7.2 U10.31
VIBRATOR_ON_G#: C99.2 Q6.1 R236.2 VR1.1
VIBRATOR_ON_R_G#: Q7.6 VR1.2
VIBRATOR_ON_S: C97.1 C99.1 HR48.2 Q6.2 R236.1
VIDALERT#: HR22.2 HR24.1 PR105.2
VIDSCLK: PR104.2 U1.N63
VIDSOUT: HR23.2 PR101.2 U1.L63
VR_HOT#: HR3.1 PC74.1 PU4.30
VRM_PWRGD: PD5.2 PR109.1 Q13.1 R60466.1 SR9206.2 U10.69
VRM_PWRGD1_A: PC77.1 PD5.1 PR109.2 PR110.2 PU4.3
VSUS_ON: PQ35.2 PR154.1 R189.1 U10.19
WIGIG_DISABLE#_EC: D14.2 U10.80
WLAN_DISABLE: CONWIFI.56 R306.2 U1.AM7
WLAN_DISABLE2: CONWIFI.54 R450.2 U1.AN5
WRST#: C195.1 D24.1 R369.2 U20.11
X2402_IN: R216.2 X2.1
X2402_OUT: C81.1 R211.2 X2.4
XDP_BPM0: U1.J60 XDP1.21
XDP_BPM1: U1.H60 XDP1.23
XDP_DBRESET#_R: GC2.1 GR6.2 GR15.2 XDP1.48
XDP_PRDY#: U1.J62 XDP1.5
XDP_PREQ#: U1.K62 XDP1.3
XDP_RST#_R: GR14.2 XDP1.46
XDP_TCK: GR2.1 GR18.1 GR19.1 R430.2 U1.E60 XDP1.57
XDP_TCK1: GR17.1 XDP1.55
XDP_TDI: GU1.3 U1.F63
XDP_TDI_BUF: GR20.1 GR21.2 GU1.2
XDP_TDO: GR1.2 GU1.11 U1.F62
XDP_TDO_BUF: GR5.2 GR16.2 GR23.1 GU1.12 XDP1.52
XDP_TMS: GU1.8 R428.2 U1.E61
XDP_TRST#: GR3.1 GU1.6 U1.AU62 U1.E59
XDP_TRST#_BUF: GU1.5 XDP1.54
XTAL_24M_IN: CKC2.1 CKR1.1 CKX1.1 U1.A25
XTAL_24M_OUT: CKC1.1 CKR1.2 CKX1.3 U1.B25
N190577: PC47.1 PR58.2
N190717: PC48.2 PC50.1
N336868: PC82.2 PR116.1
N415135: PQ13.6 PR73.2
N416456: PC65.1 PQ13.3 PR79.2 PR85.2 PU3.6
N438555: PQ25.4 PR197.1
N443953: PQ31.3 PR203.2
N456425: PR171.1 PR172.2 PU7.10
N456604: PC144.2 PR164.2 PU7.12
N479647: PQ32.3 PR209.2
N19364135: CON6.4 CON6.5 L4.2
N19719213: Q3.4 Q4.3
N19719354: Q4.1 R230.2
N19719387: Q3.1 R228.2
N19750284: Q29.6 R316.2
N19750307: Q27.3 R315.2
N19750343: Q33.3 R322.2
N19750351: Q31.3 R321.2
N19750353: Q31.6 R319.2
N19785814: PJP2.2 PQ12.1 PQ12.2 PQ12.5 PQ12.6 PQ12.7 PR74.1
N19785881: PJP4.2 PL9.2 PR92.1
N20072666: PC53.1 PQ10.2 PR70.2 PR72.1
N20635566: C86.1 Q2.1 Q2.3 U12.2
N20635568: C86.2 Q2.2 U12.3
N20750391: Q12.1 R244.2
N20750957: CR6.1 R240.2
N20750963: Q13.3 R245.2
N20750967: CR9.2 R246.1
N20750973: CR7.2 R245.1
N20751540: CR5.1 R239.2
N21452890: PC24.1 PR242.2 PR243.2 U1.AH14
N21453299: PC13.1 PC14.1 PC15.1 PL2.2 U1.B11
N21464486: PQ5.5 PQ5.6 PQ6.2 PR52.2
N21464502: PC42.1 PQ1.1 PQ5.3 PR50.2
N21464524: PQ6.6 PR49.2
N21593691: Q8.3 R237.2
N21593695: CR1.2 R237.1
N21597614: R181.1 U10.29
N22586138: PR95.1 PU3.13
N22586155: PR96.1 PU3.12
N22635369: R187.1 U10.16
N22755977: PC52.1 PQ9.5 PR69.2 PR71.1
N23444734: Q9.3 R238.2
N23444738: CR2.2 R238.1
N23444978: Q11.3 R242.2
N23444995: CR4.2 R242.1
N23445232: Q10.3 R241.2
N23445249: CR3.2 R241.1
N25225282: PC49.2 PC51.1
N25313378: Q30.3 R318.2
N26708130: Q27.6 R313.2
N27218464: HQ1.1 HR6.2
N27260469: GR10.2 GR12.1
N27578047: Q14.3 R246.2
N27745052: C144.1 Q21.3 R294.1
N27745067: C145.1 R295.1 R296.1 R298.1
N28007042: C43.2 R47.2
N28007175: C42.2 R46.2
N28055402: C46.1 R63.2
N29535167: PR26.2 U1.AL7
N29710752: CONSATA.54 R279.1
N29714116: CONWIFI.55 R307.2 R60476.2
N29714833: Q25.3 Q26.3 R310.1 R311.1
N29714844: PC43.1 Q24.3 R312.1
N29714858: C147.1 Q24.1 R311.2
N29748668: R129.2 U6.12 V1C21.1
N29748720: C68.1 R130.2 U6.34
N29865327: C200.1 R376.2 U21.7
N29865353: R377.1 U21.10
N30153364: R60365.1 U1.A8
N30155734: SR85.1 U1.R7
N30168885: C9200.1 D9200.1 Q9200.5 Q9200.6 R9204.2 T9207.1
N30168926: Q9200.2 SR9206.1
N30168991: R9203.1 R60465.2 R60466.2 R60467.2 R60468.2 R60469.1
N30187936: C45.1 R62.2
N30286706: PC197.1 U20.10
N30286716: CKC5.1 U20.8 X3.1
N30286731: R370.2 R371.2 U20.39
N30286848: D24.2 R60368.2 R60369.2
N30289244: CA11.1 UA3.14
N30327416: F3J1.10 F3R13.2 Q9202.1
N30542822: R414.2 R415.1 U17.8
N30852551: D4.1 U1.U4
N31162111: Q30.6 R432.2
N31162129: Q29.3 R433.2
N31194135: C400.1 PD8.1 PQ34.2 R436.1
N31763353: CON10.46 R60474.1 R60475.1
N31837906: PQ35.3 PR236.2 PR239.2 PR241.1
N43909756: CON7.4 D13.2
N189359983: C73.1 C74.1 R180.2 U10.74
N189359986: C78.1 C79.1 R217.1 U10.12
N189360895: D6.2 U10.15
N189360909: D7.2 U10.23
N251857507: R192.1 U10.17
N3060610255: HT94.1 U6.56
N3060610256: HT93.1 U6.57

Pads without a net: CN1 6 7; CON1 3 4; CON3 P13 P14 P15; CON5 5 7; CON6 12 13; CON8 10 11; CON10 10; CONSATA 5 6 10 11 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 38 40 42 44 46 48 59 60 61 62 63 64 65 66 67; CONWIFI 6 16 17 38 40 42 44 46 48 62 64 66 68 70; DIMM1 77 122 125 198; F3J1 9; GU2 1; HU1 1; HU4 1; J1 6 7; NOREF#3 1; NOREF#5 1; NOREF#6 1; NOREF#10 1; NOREF#19 1; NOREF#20 1; NOREF#28 1; NOREF#31 1; NOREF#33 1; NOREF#35 1; NOREF#36 1; NOREF#37 1; NOREF#38 1; NOREF#39 1; PQ6 3 4 5; PQ25 5; PQ31 5; PQ32 5; PQ35 5; PU4 5 21 22; PU8 3 5 6; Q7 3; SW1 2; U1 A21 A23 A31 AA23 AA59 AB23 AC2 AC4 AC58 AC59 AD5 AD7 AD23 AD59 AD60 AE59 AE60 AF4 AG3 AG6 AG58 AL5 AL32 AM2 AM10 AM11 AN3 AN10 AP32 AT3 AU12 AU44 AV2 AV50 AW36 AW49 AY36 AY42 AY43 B6 B14 B21 B22 B23 B31 B53 C3 C4 C15 C17 C21 C30 C31 C42 C43 D9 D17 E3 E4 E5 E6 E8 F5 F6 F8 F15 F17 G10 G15 G17 H6 H10 J6 J21 J58 K10 L59 N6 N58 P1 T59 U59 V59 Y4; U6 17 18 28 29 44 45 54 55; U9 7 12 13 14; U12 6; U13 7 24; U14 7 24; U16 2 3; U17 2 3; U19 2 3 11; U20 14 15 17 18 19 21 22 25 27 40 41 42 43 44 45 46 47 48; UA3 6

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3723 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 947 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 220 vias
v4: diameter 0.762, hole 0.254, TOP to BOTTOM, 21 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 477 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+1.05VM_VCCASW4: length 39.2
  IN2 w0.203: v1(33.5,60.37) 32.83,61.04 32.83,61.12 32.58,61.37 32.58,65.52 32.14,65.95 32.14,66.69 32.77,67.32 32.77,69.77 33.68,70.67 33.68,72.52 34.32,73.16 34.32,73.64 34.98,74.3 34.98,75.81 35.24,76.07 36.92,76.07 37.39,75.61 38.46,75.61 39.11,76.26 42.94,76.26 43.82,77.14 44.72,77.14 45.64,76.22 48.83,76.22 v1(48.93,76.33)
  BOTTOM w0.152: U1.AG14 34.54,59.71 34.27,59.44 33.95,59.44 33.89,59.51 33.5,59.89 v1(33.5,60.37)
  BOTTOM w0.254: PR40.2 48.69,78.1 48.5,77.91 48.5,77.36 48.77,77.09 48.77,76.5 v1(48.93,76.33) 49.48,76.88 v2(49.61,76.88)
+1.05VM_VCCASW5: length 39.6
  IN2 w0.203: v1(48.64,75.09) 48.46,74.91 45.95,74.91 45.1,75.75 43.43,75.75 42.1,74.41 40.87,74.41 40.49,74.79 39.23,74.79 38.72,75.3 37.36,75.3 35.62,73.56 35.62,72.83 34.04,71.25 34.04,67.54 33.5,67 33.5,62.63 32.92,62.05 32.92,61.51 33.35,61.08 v1(33.48,61.08)
  BOTTOM w0.152: v1(33.48,61.08) 33.98,60.58 34.48,60.58 34.54,60.53 U1.AG13
  BOTTOM w0.254: v1(48.64,75.09) 48.81,74.92 49.4,74.92 v2(49.61,75.13) 49.84,75.35 49.84,76.19 50.24,76.6 50.24,77.26 49.3,78.2 49.3,80.97 49.17,81.1 PR41.2
+1.05VS_AIDLE: length 18.1
  TOP w0.254: PR35.1 20.36,70.76 20.78,70.35 21.69,70.35 v2(22,70.05) 21.72,69.77 21.72,69 23.04,67.68 23.04,65.4 23.37,65.07 23.37,64.46 23.58,64.24 25.54,64.24 25.9,63.88 25.9,63.02 26.42,62.5 27.99,62.5 PC220.1 28.01,61.86 v1(28.46,61.4)
  BOTTOM w0.254: U1.N8 27.8,63.18 28.21,62.77 U1.P9 28.28,61.59 v1(28.46,61.4)
+1.05VS_APLLOPI: length 63.3
  TOP w0.508: v1(31.19,55.57) 31.31,55.68 PC16.1 ; v1(56.32,71.75) 56.45,71.88 v2(57.02,71.88)
  IN2 w0.508: v1(56.32,71.75) 57.53,70.54 64.42,70.54 66,68.96 66,68.44 65.3,67.73 63.35,67.73 62.63,68.46 60.62,68.46 59.72,67.55 59.72,64.74 57.61,62.63 54.32,62.63 53.73,62.03 53.1,62.03 52.43,61.36 45.52,61.36 44.55,60.39 40.39,60.39 39.9,59.91 36.4,59.91 35.82,59.33 32.74,59.33 31.83,58.41 31.83,56.81 31.19,56.17 v1(31.19,55.57)
  BOTTOM w0.254: U1.AA21 U1.W21 31.19,55.57 v1(31.19,55.57)
  BOTTOM w0.508: v1(56.32,71.75) 56.32,71.01 55.77,70.46 PCE1.1 53.7,71.79 PL3.2
+1.05VS_AUSB3PLL: length 56.8
  TOP w0.381: v1(18.87,52.69) 18.86,52.69 18.42,53.13 SR10.1
  TOP w0.508: SR10.1 17.96,54.06 19.08,55.19 19.08,55.95 19.27,56.14 v1(19.27,56.38) v1(19.27,57.33) 19.27,57.37 19.08,57.56 PC12.1 v2(17.32,57.56)
  IN1 w0.762: v3(13.86,70.43) 13.86,70.65 13.35,71.16 12.5,71.16 12.24,70.91 9.32,70.91 v3(8.21,72.03)
  IN2 w0.762: v3(8.21,72.03) 8.21,62.86 13.67,57.4 18.37,57.4 ; v3(13.98,82.4) 13.98,81.87 11.03,78.91 11.03,78.05 v3(10.24,77.26)
  IN3 w0.762: v3(10.24,77.26) 11.13,76.37 11.13,75.43 11.79,74.77 11.79,73.58 12.57,72.79 v3(12.57,72.69)
  BOTTOM w0.254: v1(19.27,57.33) 19.27,57.13 19.63,56.76 20.99,56.76 U1.B18 ; 19.91,52.09 20.17,52.35 20.71,52.35 21.09,51.96 U1.B27
  BOTTOM w0.381: 19.91,52.09 19.47,52.09 v1(18.87,52.69)
  BOTTOM w0.762: v3(12.57,72.69) 12.93,72.33 PC7.1 13.76,71.99 13.86,71.89 v3(13.86,70.43)
+1.05VS_HSIO: length 96.8
  TOP w0.508: v2(8.21,73.17) 8.43,73.17 v3(9.22,72.38) 9.5,72.1 SR7.2
  TOP w0.762: PR32.1 17.35,82.16 17.98,82.8 17.98,83.23 v3(17.86,83.35)
  IN2 w0.254: 24.59,85.77 27.41,85.77 27.7,86.06 30.19,86.06 30.57,86.44 31.24,86.44
  IN2 w0.508: 31.24,86.44 31.24,87.24 31.04,87.44 25.55,87.44 24.64,86.53 24.64,85.81 24.59,85.76
  IN2 w0.762: v3(52.99,85.95) 52.49,86.44 38.79,86.44 38.26,86.97 37.1,86.97 36.56,86.44 31.24,86.44 ; 24.59,85.76 23.12,84.29 18.47,84.29 17.86,83.68 v3(17.86,83.35) ; v1(15.61,81.68) 15.61,80.88 14.4,79.67 14.4,78.55 13.48,77.63 12.87,77.63 9.86,74.62 8.84,74.62 8.23,74.01 8.23,73.37 v3(9.22,72.38) 10.21,71.39 10.21,62.3 13.29,59.22 16.71,59.22 v3(17.55,60.06)
  IN3 w0.762: v1(15.61,81.68) 17.26,83.33 17.83,83.33 v3(17.86,83.35)
  BOTTOM w0.254: U1.A12 18.18,60.69 v3(17.55,60.06)
  BOTTOM w0.762: v3(52.99,85.95) 53.32,85.62 55.78,85.62 56.12,85.27 PR49.1 56.68,84.25 PQ1.2
+1.05VS_PWRGD: length 18.4
  BOTTOM w0.102: v1(88.34,5.96) 88.65,6.26 88.65,7.14 88.93,7.42 89.52,7.42 90.41,6.53 GU1.10 92.77,6.53 93.73,7.48 v2(93.93,7.48) ; v1(88.34,5.96) 87.92,6.38 87.4,6.38 86.91,5.88 GU1.4 ; v1(88.34,5.96) 89.72,4.58 GU1.13 ; v1(88.34,5.96) 88.34,5.55 87.61,4.82 87.61,4.44 87.1,3.93 GU1.1
+1.05VS_PWRGD_S: length 110.2
  TOP w0.102: GR7.2 62.13,4.4 62.13,4.28 v1(62.23,4.18)
  IN1 w0.102: v1(62.23,4.18) 63.12,3.29 84.84,3.29 85.7,4.16 88.59,4.16 91.5,7.07 93.23,7.07 93.58,7.41 100.21,7.41 v1(100.64,6.99)
  IN2 w0.102: v1(14.6,30.25) 16.13,28.72 16.13,23.1 25.27,13.96 40.56,13.96 44.63,9.89 44.63,8.03 47.98,4.68 49.39,4.68 50.58,3.48 61.53,3.48 v1(62.23,4.18)
  BOTTOM w0.102: v1(100.64,6.99) 99.61,5.96 HR47.2 98.44,5.96 98.38,6.03 HU4.4 ; HR27.1 14.95,29.9 14.6,30.25 v1(14.6,30.25) ; v1(62.23,4.18) v2(62.23,3.4)
+1.05VS_PWRGD_S_R: length 8.4
  BOTTOM w0.089: U1.B59 20.84,31.58 20.07,31.58 18.38,29.9 18.15,29.9
  BOTTOM w0.102: 18.15,29.9 HR27.2 16.2,29.45 16.11,29.35 14.3,29.35 v2(14.12,29.18)
+1.05VS_PWRGD_XDP: length 25.8
  TOP w0.102: v2(60,3.57) 63.03,3.57 63.37,3.92 63.37,4.51 62.97,4.92 GR7.1 62.85,5.28 65.07,5.28 65.47,5.68 65.47,7.78 66.51,8.81 73.41,8.81 76.78,5.45 XDP1.39
+1.05VS_VCC_AXCK_DCB: length 35.6
  TOP w0.152: v2(17.68,74.85) 17.68,74.54 v1(18,74.21)
  TOP w0.457: v1(25.45,57.11) 25.65,56.91 PC34.1
  IN2 w0.127: 22.82,61.42 22.28,61.97 22.28,62.25 22.19,62.34 25.67,62.34 26.11,61.89 26.11,61.51 25.73,61.51 25.64,61.42 22.82,61.42
  IN2 w0.254: 22.19,62.34 20.59,63.94 20.59,67.49 17.4,70.68 17.4,73.9 17.72,74.21 v1(18,74.21) ; 26.11,61.51 26.11,57.77 v1(25.45,57.11)
  BOTTOM w0.254: U1.K19 25.74,57.58 U1.J18 25.45,57.3 v1(25.45,57.11) ; v1(18,74.21) 18.3,74.21 PCE2.1 19.68,73.51 19.48,73.7 PL4.2
+1.05VS_VCCACLKPLL: length 20.4
  TOP w0.381: v2(19.94,54.53) 20.68,55.26 PC35.1 20.28,56.02 20.08,56.02 v1(19.74,55.68)
  IN3 w0.381: v1(13.77,42.56) 15.01,43.81 15.56,43.81 17.21,45.46 17.21,50.69 17.96,51.44 17.96,52.09 18.24,52.37 18.24,52.98 19.74,54.47 v1(19.74,55.68)
  BOTTOM w0.254: U1.A20 20.27,56.28 19.74,55.74 v1(19.74,55.68)
+1.05VS_VCCHSIO: length 52.9
  TOP w0.457: v1(27.33,62.02) 26.98,62.02 26.9,61.94 PC4.1 ; PC3.1 28.19,60.78 27.56,61.41 v1(27.25,61.41)
  TOP w0.508: v2(18.72,76.27) 18.72,76.97 v3(18.98,77.22)
  TOP w0.762: PR32.2 18.54,77.92 18.98,77.49 v3(18.98,77.22)
  IN1 w0.178: v1(27.25,61.41) 26.56,61.41 25.63,62.35 23.85,62.35 23.83,62.32 22.66,62.32 22.4,62.58 22.4,63.96 22.77,64.33 22.96,64.33 23.32,64.69 23.32,64.99 23.09,65.22 23.09,65.93 22.86,66.16 22.86,67.12 23.24,67.51 24.39,67.51 ; v1(27.33,62.02) 27.33,62.78 26.85,63.26 26.85,65.82 25.26,67.41
  IN1 w0.203: v1(27.25,61.41) 26.75,61.92 26.75,62.08 25.53,63.3 23.87,63.3 23.6,63.57 23.6,64.3 23.62,64.33 23.62,64.88 24.51,65.77 24.51,66.49 24.65,66.63 24.65,67.07
  IN1 w0.254: v1(27.33,62.02) 26.64,62.71 26.57,62.71 25.9,63.37 25.9,66.22 24.97,67.15
  IN1 w0.762: 24.31,67.79 24.31,68.52 v3(22.86,69.97)
  IN2 w0.762: v3(22.86,69.97) 22.81,69.97 18.98,73.8 v3(18.98,77.22)
  BOTTOM w0.254: v1(27.33,62.02) 27.16,62.02 U1.L10 26.8,62.33 26.37,62.76 U1.K9 ; v1(27.33,62.02) 27.33,61.49 v1(27.25,61.41) ; v1(27.33,62.02) 27.33,62.77 U1.M9
+1.05VSUS_AOSCSUS: length 2.3
  TOP w0.457: PC38.1 32.45,62.84 v1(33.04,63.43)
  TOP w0.508: v2(32.79,64.08) 33.04,63.83 v1(33.04,63.43)
  BOTTOM w0.254: v1(33.04,63.43) 33.03,63.43 32.81,63.22 U1.AB8
+3VA: length 408.3
  TOP w0.254: v1(46.32,70.55) 46,70.24 PR30.1 ; PR12.1 47.28,76.9 v1(48.26,76.9) 48.43,77.07 49.21,77.07 49.49,77.35 49.49,78.02 49.32,78.2 SR97.1 48.11,77.75 47.84,77.49 46.6,77.49 46.3,77.18 v1(45.63,77.18) ; R320.1 180.17,73.56 179.27,74.45 179.27,75.63 178.87,76.04 177.04,76.04 175.72,77.36 170.03,77.36 v1(169.17,78.22) 168.1,77.16 168.1,74.98 167.69,74.57 167.69,69.78 167.9,69.57 R314.1 ; v1(45.06,79.77) 44.93,79.65 43.31,79.65 43.08,79.41 43.08,78.26 42.35,77.53 40.72,77.53 39.13,75.94 39.13,73.11 38.73,72.71 38.59,72.71 PR29.1 ; v1(56,79.11) 55.95,79.06 55.95,75.9 55.64,75.59 55.64,74.8 54.52,73.68 54.52,71.71 54.31,71.49 PR44.2 53.79,70.92 v1(53.38,70.51)
  TOP w0.457: v1(116.03,82.19) 116.03,82.67 115.64,83.06 C82.1 115.01,83.71 115.03,83.73 R180.1
  TOP w0.508: CR1.1 127.5,86.52 126.63,86.52 v1(126.32,86.83)
  IN1 w0.508: v1(163.43,76.93) 164.39,76.93 166.04,78.58 v1(166.7,78.58) 168.81,78.58 v1(169.17,78.22) ; 137.63,48.86 137.52,48.86 135.26,51.12 v1(135.26,51.23) 135.64,51.23 136.2,51.78 136.2,52.85 v1(135.42,53.63) 135.77,53.98 136.16,53.98 136.6,54.42 136.6,55.11 137.03,55.54 v1(137.03,56.86) 137.03,57.55 136.49,58.09 135.02,58.09 134.8,57.88 131.14,57.88 128.54,60.48 126.25,60.48 124.97,61.76 123.76,61.76 122.35,60.35 ; 137.63,48.86 138.06,49.29 141.18,49.29 141.73,49.84 141.73,53.13 144.8,56.2 147.38,56.2 155.06,63.89 158.48,63.89 161.27,66.67 v1(161.93,66.67) ; 137.63,48.86 137.63,47.96 136.32,46.65 136.32,45.28 136.66,44.94 v1(137.07,44.94) ; v1(43.42,83.18) 44.21,82.39 44.21,80.62 v1(45.06,79.77) 45.98,78.86 45.98,77.52 v1(45.63,77.18) ; v1(122.91,69.74) 122.91,69.91 123.45,70.45 124.3,70.45 125.22,71.37 128.2,71.37 129.67,72.84 132.95,72.84 134.02,71.77 144.17,71.77 146.33,69.61 146.33,66.49 147.46,65.36 155.34,65.36 v1(155.83,65.85) ; v3(118.44,55.67) 119.74,56.96 121.54,56.96 122.35,57.78 122.35,60.35 ; v1(114.3,62.22) 114.3,63.72 115.09,64.51 117.35,64.51 118.18,63.68 118.18,62.64 v1(118.37,62.45) 118.95,62.45 121.05,60.35 122.35,60.35
  IN2 w0.254: v1(57.17,65.37) 57.17,66.47 53.49,70.15 53.49,70.39 v1(53.38,70.51) 52.88,70.02 50.55,70.02 50.29,69.77 47.11,69.77 v1(46.32,70.55)
  IN2 w0.508: v1(86.34,79.01) 83.01,79.01 82.01,80.01 77.17,80.01 76.34,80.84 68.73,80.84 68.18,80.29 67.23,80.29 65.37,78.43 63.98,78.43 63.76,78.66 58.78,78.66 58.47,78.96 56.15,78.96 v1(56,79.11) 55.08,80.03 54.76,80.03 54.25,80.54 50.05,80.54 49.03,79.53 46.09,79.53 45.85,79.76 45.07,79.76 v1(45.06,79.77) ; v1(86.97,82.47) 86.98,82.45 89.11,82.45 89.49,82.07 92.11,82.07 92.46,82.43 94.41,82.43 94.7,82.14 98.27,82.14 99.1,82.96 106.1,82.96 106.29,83.15 110.23,83.15 110.82,82.56 110.82,82.32 111.31,81.82 113.25,81.82 113.62,82.19 v1(116.03,82.19) 118.58,82.19 119.2,81.56 119.72,81.56 120.96,82.81 123.48,82.81 123.85,82.45 142.76,82.45 145.23,79.98 148.67,79.98 150.01,78.63 150.01,77.41
  IN2 w1.27: 105.36,40.81 107.19,38.98 111.79,38.98 112.94,40.14 112.94,44.03 113.66,44.75 113.66,46.35 112.5,47.52 112.5,54.88 113.16,55.54 116.88,55.54
  BOTTOM w0.254: R89.1 56.41,65.6 56.64,65.37 v1(57.17,65.37) ; PR36.1 42.69,75.7 42.93,75.94 43.16,75.94 44.4,77.18 45.62,77.18 45.62,77.18 v1(45.63,77.18)
  BOTTOM w0.381: PC201.1 44.26,84.45 43.84,84.03 PQ33.3 43.5,83.26 v1(43.42,83.18)
  BOTTOM w0.406: R347.1 122.15,70.46 122.88,69.74 v1(122.91,69.74)
  BOTTOM w0.457: v1(135.42,53.63) PR81.1 ; PR80.1 137.03,56.16 v1(137.03,56.86) ; PR82.1 135.41,51.08 v1(135.26,51.23) ; PR83.1 v1(137.07,44.94)
  BOTTOM w0.508: v1(86.34,79.01) 86.34,79.71 86.02,80.02 86.02,81.51 v1(86.97,82.47) 85.4,84.04 85.4,87 SR9.1 ; v1(116.03,82.19) 116.03,81.75 116.33,81.45 120.52,81.45 120.85,81.12 ; v1(166.7,78.58) 167.02,78.58 167.39,78.95 167.39,79.65 167.94,80.2 D1.1 ; PR144.1 118.71,62.11 v1(118.37,62.45) ; v1(114.3,62.22) 114.25,62.27 R218.2 ; v1(126.32,86.83) 125.68,86.2 125.68,84.55 124.51,83.38 124.51,81.86 123.98,81.32 121.06,81.32 120.85,81.12 ; R179.1 119.77,73.81 120.3,74.34 120.3,77.89 120.85,78.45 120.85,81.12
  vias: v2(104.8,42.35) v3(103.91,42.28) v3(104.52,41.55) v3(117.55,55.67)
+3VA_BST1_D: length 1.2
  TOP w0.508: v2(117.76,64.94) 117.76,65.33 v1(118.31,65.89)
+3VA_BST_D: length 1.2
  TOP w0.508: v2(119.84,65.17) 120.19,64.81 v1(120.91,64.81)
+3VA_CS_A: length 3.1
  BOTTOM w0.203: PR152.2 121.7,60.22 122.6,61.12 PU6.5
  BOTTOM w0.254: PR152.2 121.6,60.13 120.97,59.49 v2(120.97,59.1)
+3VA_EC: length 146.3
  TOP w0.178: v1(106.82,88.37) 105.61,89.58 99.65,89.58 98.81,88.73 98.81,86.02 v1(97.64,84.85)
  TOP w0.254: R199.1 108.11,80.04 v1(107.93,80.23) ; R199.1 R200.1 ; R199.1 R201.1 ; v1(103.39,80.23) 103.2,80.23 102.48,80.95 R175.1
  TOP w0.457: C70.1 112.69,78.03 v1(112.78,77.94)
  TOP w0.508: v1(100.76,75.21) 101.39,75.84 103.63,75.84 R174.1 103.72,75.5 v1(103.43,75.21) ; v1(100.76,75.21) 100.92,75.06 100.92,73.98 101.22,73.67 R206.1 ; v1(100.76,75.21) 99.67,74.12 99.67,73.77 99.63,73.74 99.63,72.67 100.48,71.82 v1(100.48,71.13) ; D8.1 108.48,70.65 v1(107.72,69.89) 107.72,69.42 R229.1 107.43,68.6 106.55,67.73 104.5,67.73 v2(104.07,67.3) 102.49,68.88 102.49,69.41 102.99,69.91 v1(103.6,69.91)
  IN1 w0.508: v1(112.78,77.94) 112.78,77.08 113.28,76.57 115.32,76.57 118.52,73.37 v1(118.52,72.1)
  IN2 w0.127: v1(104.97,80.23) 105.4,79.8 107.49,79.8 v1(107.93,80.23) 107.49,80.66 105.4,80.66 v1(104.97,80.23) ; v1(104.97,80.23) 104.54,80.66 103.82,80.66 v1(103.39,80.23) 103.82,79.8 104.54,79.8 v1(104.97,80.23)
  IN2 w0.254: v1(79.15,86.88) 79.15,86.45 79.61,86 83.59,86 84.05,85.54 84.05,84.92 84.39,84.57 85.55,84.57 86.05,84.08 87.62,84.08 88.16,84.61 93,84.61 93.75,85.36 96.49,85.36 97,84.85 v1(97.64,84.85)
  IN2 w0.508: v1(106.05,72.64) 107.72,70.96 v1(107.72,69.89) 108.64,68.98 117,68.98 117.86,69.83 117.86,71.44 v1(118.52,72.1)
  IN3 w0.508: v1(103.6,69.91) 102.14,69.91 100.92,71.13 v1(100.48,71.13)
  BOTTOM w0.178: v1(112.78,77.94) 112.78,77.77 113.21,77.33 U10.92 ; C69.1 96.47,85.54 97.16,84.85 v1(97.64,84.85) 97.81,85.03 97.81,85.54 98.01,85.73 U10.26 ; C76.1 106.53,71.81 106.53,73 106.18,73.34 U10.114 ; U10.50 107.38,88.93 v1(106.82,88.37) 105.89,87.44 105.54,87.44 105.44,87.34 105.44,86.49 104.27,85.32 104.27,84.14 103.1,82.97 103.1,81.63 103.51,81.22 103.98,81.22 v1(104.97,80.23) ; U10.127 100.98,74.99 v1(100.76,75.21) ; v1(103.43,75.21) 103.38,75.16 U10.121
  BOTTOM w0.254: v1(79.15,86.88) 78.86,87.17 R435.1
  BOTTOM w0.406: C75.1 118.6,71.01 118.25,71.35 D5.1 117.48,71.35 117.27,71.56 R193.1
  BOTTOM w0.457: R193.1 R194.1 ; R179.2 118.43,73.27 118.11,73.59 R204.1 R203.1 ; C71.1 100.48,71.62 v1(100.48,71.13) 100.93,71.13 R190.1 ; R191.1 R202.1 103.68,69.99 v1(103.6,69.91) ; C76.1 106.05,71.53 v1(106.05,72.64) ; R195.1 R196.1 107.8,69.97 v1(107.72,69.89)
  BOTTOM w0.508: C75.1 119.24,71.38 v1(118.52,72.1) 118.43,72.19 R179.2 ; v1(103.43,75.21) 103.43,76.72 104.15,77.44 104.15,78.77 103.39,79.53 v1(103.39,80.23)
+3VA_EN_A: length 4.7
  BOTTOM w0.203: PU6.6 121.55,62.03 PC138.1 120.17,60.65 119.9,60.65 v2(119.43,60.18) 118.89,60.72 118.7,60.72 PR155.2
+3VA_FB1_A: length 5.5
  TOP w0.254: v1(121.67,55.97) 121.11,55.97 120.92,56.16 v2(120.92,56.91) PC141.1 120.92,58.32 120.93,58.33 PR158.1 120.55,58.75 120.52,58.78 PC140.1
  BOTTOM w0.152: v1(121.67,55.97) 121.29,56.36 PJP13.1
+3VA_FB_A: length 6.4
  TOP w0.254: v1(121.62,59.43) 121.46,59.59 PR158.2 120.53,59.59 120.5,59.62 PC140.2 ; PC140.2 PR159.1 ; PC140.2 120.09,60.2 v2(119.66,60.62)
  BOTTOM w0.203: v1(121.62,59.43) 121.87,59.43 122.86,60.42 122.86,60.76 123,60.89 PU6.4
