# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_MAA4: length 132.6
  TOP w0.102: U4.P8 82.84,59.61 84.12,59.61 84.2,59.69 v1(84.63,59.69) ; v1(82.78,38.94) 82.78,38.94 U3.P8 ; U2.P8 82.53,27.96 82.65,27.96 82.96,28.27 83.32,28.27 83.52,28.47 83.52,28.75 83.32,28.95 83.18,28.95 82.88,29.25 82.88,29.61 83.17,29.9 83.83,29.9 84.58,29.15 v1(84.58,28.59) ; U5.P8 v1(82.78,70.29)
  TOP w0.267: R13.1 87.02,47.26 v2(86.5,46.74) 85.83,46.07 v1(85.14,46.07)
  IN1 w0.102: v1(82.78,70.29) 82.78,68.83 84.29,67.31 84.29,64.65 84.69,64.26 84.69,63.38 85.1,62.96 85.1,62.77 v1(85.32,62.55) 85.1,62.34 85.1,61.03 84.66,60.59 84.66,60.24 84.81,60.09 85.42,60.09 85.52,59.99 85.52,59.83 85.42,59.73 85.19,59.73 85.09,59.63 85.09,59.39 84.93,59.24 84.27,59.24 84.15,59.35 84.15,59.51 84.33,59.69 v1(84.63,59.69) ; v1(82.78,38.94) 82.33,38.94 82.22,38.83 82.22,38.62 82.95,37.89 82.95,37.43 84.14,36.23 84.14,34.21 84.57,33.78 84.57,32.03 v1(84.79,31.82) 84.96,31.64 84.96,30.32 84.58,29.94 v1(84.58,28.59)
  IN2 w0.089: v1(41.47,44.22) 42.4,43.29 46.41,43.29 47.61,42.09 49.51,42.09
  IN2 w0.33: v1(85.14,46.07) 84.66,45.59 84.16,45.59 83.66,45.09 73.25,45.09 72.41,44.25 69.07,44.25 67.39,42.57 67.39,41.75 67.21,41.57 66.28,41.57 65.95,41.24 65.95,39.72 66.27,39.4 66.27,39.13 65.99,38.85 62.04,38.85 61.55,39.34 59.98,39.34 59.81,39.17 59.81,38.08 58.3,36.57 56.54,36.57 51.02,42.09 49.51,42.09
  BOTTOM w0.089: U1.AU39 41.19,44.5 v1(41.47,44.22)
  BOTTOM w0.102: v1(85.32,62.55) 85.1,62.34 85.1,60.22 85.11,60.22 85.11,56.89 85,56.79 84.43,56.79 84.33,56.69 84.33,56.14 84.43,56.04 85,56.04 85.11,55.94 85.11,55.3 85,55.2 84.43,55.2 84.33,55.1 84.33,54.38 84.43,54.28 85,54.28 85.11,54.18 85.11,52.87 84.87,52.64 84.87,46.33 v1(85.14,46.07) 85.14,44.69 85.02,44.58 85.02,43.99 84.76,43.73 84.76,42.97 84.61,42.82 84.61,41.19 84.41,40.99 84.41,38.18 84.75,37.83 84.75,33.46 84.57,33.28 84.57,32.46 84.04,31.92 84.04,30.4 84.14,30.3 84.69,30.3 84.79,30.4 v1(84.79,31.82)
M_CHA_MAA5: length 133.8
  TOP w0.102: U5.P2 82.23,65.89 82.13,65.99 82.13,66.24 82.23,66.34 82.45,66.34 82.7,66.09 82.9,66.09 83.02,66.22 83.02,66.36 82.72,66.66 82.72,67.01 v1(82.88,67.17) ; v1(82.96,57.39) 83.38,56.97 83.38,56.44 82.72,55.78 82.72,54.88 82.38,54.54 U4.P2 ; U3.P2 82.38,34.23 82.48,34.13 82.65,34.13 82.84,34.32 82.84,34.97 82.72,35.08 82.72,35.69 v1(82.88,35.85) ; U2.P2 82.38,22.75 82.48,22.65 82.68,22.65 82.78,22.75 82.78,24.01 83.37,24.6 83.37,25.99 v1(83.29,26.06)
  TOP w0.267: v1(78.72,48.18) 78.45,47.91 R14.1
  IN1 w0.102: v1(82.88,35.85) 83.14,36.1 83.29,36.1 83.47,35.93 83.47,35.5 83.31,35.35 82.72,35.35 82.62,35.25 82.62,33.75 82.72,33.65 83.38,33.65 83.47,33.57 83.47,33.34 83.36,33.24 83.21,33.24 83.14,33.16 83.14,33 83.23,32.91 83.42,32.91 83.47,32.86 83.47,32.53 83.33,32.39 83.33,32.11 v1(83.62,31.82) 83.62,30.73 83.12,30.22 83.12,27.74 83.29,27.56 v1(83.29,26.06) ; v1(82.88,67.17) 83.12,67.4 83.29,67.4 83.5,67.19 83.5,64.13 83.85,63.79 83.85,62.91 83.95,62.81 84.39,62.81 84.49,62.7 84.49,62.44 84.41,62.35 v1(84.08,62.35) 84.04,62.31 84.04,60.26 83.78,60 83.48,60 83.39,59.91 83.39,57.52 83.26,57.39 v1(82.96,57.39)
  IN2 w0.089: 49.51,44.7 48.06,44.7 47.83,44.92 41.58,44.92 40.39,46.11 40.04,46.11 v1(39.59,45.66)
  IN2 w0.33: v1(78.72,48.18) 78.23,47.69 71.69,47.69 71.51,47.52 71.51,47.03 71.33,46.85 68.39,46.85 68.19,47.06 68.19,47.52 67.98,47.72 67.52,47.72 67.31,47.52 67.31,46.53 67.13,46.35 66.87,46.35 66.37,46.85 65.3,46.85 65.12,46.68 65.12,45.75 63.29,43.93 63.29,42.58 63.13,42.42 62.47,42.42 62.26,42.64 62.26,43.35 61.99,43.62 60.47,43.62 60.3,43.78 59.85,43.78 59.56,43.49 59.56,43.2 59.92,42.84 59.92,42.52 59.35,41.95 58.9,41.95 58.02,41.07 57.41,41.07 57.15,40.81 57.15,40.41 56.97,40.23 56.56,40.23 52.1,44.7 49.51,44.7
  BOTTOM w0.089: U1.AR36 39.59,45.79 v1(39.59,45.66)
  BOTTOM w0.102: v1(84.08,62.35) 83.82,62.09 83.82,61.46 84.04,61.24 84.04,60.27 83.77,60 83.48,60 83.38,59.9 83.38,56.37 83.22,56.21 82.81,56.21 82.7,56.11 82.7,53.87 82.81,53.76 83.5,53.76 83.6,53.66 83.6,51.39 82.75,50.54 82.48,50.54 81.78,49.84 81.78,48.37 81.59,48.18 80.18,48.18 80.08,48.07 80.08,47.46 79.97,47.36 79.77,47.36 79.67,47.46 79.67,48.07 79.57,48.18 v1(78.72,48.18) 78.72,47.39 79.25,46.85 80.37,46.85 v2(80.92,46.3) 83.51,43.71 83.51,38.42 83.2,38.12 83.2,37.44 83.51,37.13 83.51,35.49 83.33,35.3 83.33,32.29 83.14,32.1 83.14,31.59 83.26,31.46 83.52,31.46 83.62,31.56 v1(83.62,31.82)
M_CHA_MAA6: length 131.7
  TOP w0.102: v1(82.79,39.74) 82.8,39.73 82.8,39.73 U3.R8 ; v1(83.58,70.29) 83.56,70.32 83.55,70.32 U5.R8 ; U2.R8 82.81,27.81 82.71,27.71 82.71,27.45 82.81,27.35 83.5,27.35 83.61,27.47 84.01,27.47 84.26,27.21 84.56,27.21 84.64,27.29 v1(84.64,27.47) ; U4.R8 83.18,59.35 83.13,59.41 82.92,59.41 82.73,59.21 82.73,58.8 82.83,58.7 83.29,58.7 83.49,58.89 83.72,58.89 83.92,58.7 84.43,58.7 v1(84.55,58.82)
  TOP w0.267: v2(85.4,48.07) v1(85.4,47.19) 86.03,47.19 86.6,47.75 87.73,47.75 R15.1
  IN1 w0.102: v1(83.58,70.29) 83.58,68.42 84.55,67.45 84.55,64.68 84.87,64.36 85.74,63.49 85.74,62.16 v1(85.53,61.95) 85.31,61.73 85.31,60.76 85.22,60.67 85.03,60.67 84.92,60.56 84.92,60.42 85.02,60.32 85.64,60.32 85.72,60.24 85.72,60.1 85.8,60.01 86.06,60.01 86.13,59.94 86.13,59.63 86.03,59.53 85.57,59.53 85.22,59.18 85.22,58.95 85.09,58.82 v1(84.55,58.82) ; v1(84.64,27.47) 84.85,27.69 84.85,28.22 84.85,28.22 84.85,28.23 85.21,28.59 85.21,32.21 v1(84.99,32.43) 84.78,32.64 84.78,33.87 84.4,34.25 84.4,36.34 83.2,37.53 83.2,39.33 v1(82.79,39.74)
  IN2 w0.089: v1(43.89,43.88) 46.69,43.88 47.22,43.35 48.41,43.35 48.63,43.13 49.51,43.13
  IN2 w0.33: 49.51,43.13 51.45,43.13 56.97,37.61 57.87,37.61 58.76,38.51 58.76,39.6 59.55,40.39 62.47,40.39 62.95,40.86 64.59,40.86 64.86,41.12 64.86,42.94 65.48,43.56 66.91,43.56 68.64,45.29 71.98,45.29 72.82,46.13 83.23,46.13 83.77,46.68 83.77,47.18 84.35,47.76 86.2,47.76 86.69,47.26 86.69,46.82 86.44,46.57 86.13,46.57 85.52,47.19 v1(85.4,47.19)
  BOTTOM w0.089: U1.AV40 42.13,43.52 43.54,43.52 43.89,43.86 v1(43.89,43.88)
  BOTTOM w0.102: v1(84.99,32.43) 84.79,32.63 84.79,33.21 84.95,33.37 84.95,37.92 84.61,38.26 84.61,40.9 84.71,41 85.4,41 85.5,41.11 85.5,41.37 85.4,41.47 85.02,41.47 84.91,41.57 84.91,41.83 85.02,41.93 85.36,41.93 85.46,42.03 85.46,42.26 85.36,42.36 85.02,42.36 84.91,42.46 84.91,42.69 85.02,42.8 85.36,42.8 85.46,42.9 85.46,43.82 85.33,43.95 85.33,44.45 85.57,44.7 85.57,47.01 v1(85.4,47.19) 85.45,47.24 85.45,48.37 85.18,48.64 85.18,52.57 85.31,52.7 85.31,54.28 85.11,54.48 84.64,54.48 84.54,54.58 84.54,54.9 84.64,55 85.21,55 85.31,55.1 85.31,56.03 85.1,56.24 84.71,56.24 84.61,56.34 84.61,56.49 84.71,56.59 85.12,56.59 85.31,56.78 85.31,60.3 85.31,60.3 85.31,61.73 v1(85.53,61.95)
M_CHA_MAA7: length 132.8
  TOP w0.102: v1(83.58,54.74) 82.93,54.74 82.83,54.64 82.83,54.46 82.93,54.35 U4.R2 ; v1(86.69,64.05) 85.88,64.05 85.37,64.56 85.37,65.4 85.24,65.52 85.04,65.52 84.91,65.4 84.91,63.9 84.79,63.77 84.53,63.77 84.41,63.9 84.41,65.44 84.3,65.54 83.84,65.54 83.5,65.89 U5.R2 ; U2.R2 83.58,23.41 v1(83.58,23.41) ; v1(85.86,34.53) v2(86.67,34.53) 87.15,34.53 87.28,34.4 87.28,33.91 87.2,33.84 84.55,33.84 84.18,34.2 83.84,34.2 83.5,34.54 U3.R2
  TOP w0.267: v1(86.97,45.86) 87.57,45.25 87.61,45.25 87.83,45.03 R16.1
  IN1 w0.102: v1(86.69,64.05) 87.05,63.7 87.05,61.6 v1(86.85,61.4) 87.05,61.21 87.05,59.21 85.36,57.52 85.36,56.63 84.9,56.18 84.41,56.18 84.13,55.9 84.13,55.31 84.25,55.19 84.53,55.19 84.62,55.1 84.62,54.84 84.52,54.74 83.58,54.74 v1(83.58,54.74) ; v1(83.58,23.41) 84.3,24.14 84.3,24.68 86.3,26.68 86.3,29.34 86.67,29.71 86.67,32.06 v1(86.25,32.48) 86.68,32.91 86.68,35.23 86.49,35.42 86.06,35.42 85.86,35.22 v1(85.86,34.53)
  IN2 w0.089: 49.51,42.61 48.48,42.61 47.99,43.1 47.22,43.1 46.85,43.47 43.44,43.47 42.8,44.11 v1(42.8,44.22)
  IN2 w0.33: 49.51,42.61 51.23,42.61 56.75,37.09 58.08,37.09 59.29,38.3 59.29,39.38 59.77,39.87 62.69,39.87 63.16,40.34 64.11,40.34 64.28,40.16 64.28,39.55 64.46,39.37 65.2,39.37 65.38,39.55 65.38,42.29 65.56,42.47 66.56,42.47 68.86,44.77 72.19,44.77 73.03,45.61 83.44,45.61 84.43,46.6 85.36,46.6 86.4,45.56 86.67,45.56 v1(86.97,45.86)
  BOTTOM w0.089: v1(42.8,44.22) 42.49,44.52 U1.AW39
  BOTTOM w0.102: v1(86.25,32.48) 86.69,32.92 86.69,32.92 86.91,33.14 86.91,33.44 86.81,33.55 85.96,33.55 85.85,33.65 85.85,33.8 85.96,33.9 86.81,33.9 86.91,34 86.91,44.7 87.09,44.88 87.09,45.17 86.79,45.47 86.79,45.68 v1(86.97,45.86) 86.97,46.16 86.79,46.34 86.79,54.04 87.07,54.32 87.07,57.47 86.85,57.69 v1(86.85,61.4)
M_CHA_MAA8: length 129.6
  TOP w0.102: v1(87.31,32.1) 86.91,32.5 v2(86.91,32.74) ; U2.T8 84.33,28.16 84.74,28.16 85.07,28.49 86.82,28.49 v1(87,28.67) ; v1(86.05,57.26) 86.05,57.9 84.72,59.24 84.06,59.24 U4.T8 ; U3.T8 84.93,39.34 v1(85.03,39.44) ; U5.T8 84.37,70.3 v1(84.54,70.3)
  TOP w0.267: R17.1 88.04,46.12 v1(87.53,46.63)
  IN1 w0.102: v1(86.05,57.26) 87.34,57.26 87.48,57.39 87.48,61.48 87.89,61.9 v1(87.89,62.2) 88.31,62.62 88.31,65.11 85.93,67.49 85.93,68.63 85.02,69.54 85.02,69.81 v1(84.54,70.3) ; v1(85.03,39.44) 84.95,39.36 84.95,38.68 85.32,38.32 86.84,38.32 87.1,38.07 87.1,32.31 v1(87.31,32.1) 87.58,31.83 87.58,31.03 87.45,30.9 87.17,30.9 87.1,30.83 87.1,30.62 87.17,30.55 87.51,30.55 87.58,30.47 87.58,30.23 87.48,30.13 87.2,30.13 87.1,30.03 87.1,29.8 87.2,29.7 87.48,29.7 87.58,29.6 87.58,29.18 87.5,29.1 87.3,29.1 87.1,29.3 86.84,29.3 86.72,29.18 86.72,28.95 v1(87,28.67)
  IN2 w0.089: 49.51,43.65 47.35,43.65 46.66,44.34 v1(44.86,44.34)
  IN2 w0.33: v1(87.53,46.63) 88.03,46.63 88.22,46.81 88.22,47.54 88.04,47.72 86.99,47.72 86.43,48.28 84.13,48.28 82.51,46.65 72.6,46.65 71.76,45.81 68.42,45.81 66.82,44.21 65.39,44.21 64.34,43.16 64.34,41.75 63.97,41.38 61.63,41.38 61.19,41.82 60.7,41.82 60.38,41.51 60.38,41.11 60.18,40.91 59.34,40.91 58.24,39.81 58.24,38.73 57.65,38.13 57.19,38.13 51.66,43.65 49.51,43.65
  BOTTOM w0.089: v1(44.86,44.34) 44.78,44.34 44.49,44.63 U1.AY39
  BOTTOM w0.102: v1(87.89,62.2) 87.89,61.87 87.48,61.46 87.48,61.11 87.74,60.84 87.74,46.84 v1(87.53,46.63) 87.74,46.41 87.74,44.67 87.52,44.45 87.52,43.78 87.62,43.68 87.99,43.68 88.09,43.58 88.09,42.64 87.99,42.54 87.62,42.54 87.52,42.44 87.52,33.17 87.2,32.86 87.2,32.21 v1(87.31,32.1)
M_CHA_MAA9: length 133.1
  TOP w0.102: U4.R3 83.18,55.27 v1(83.6,55.69) ; v1(83.85,24.37) 83.29,23.81 U2.R3 ; U3.R3 83.5,35.34 83.64,35.49 83.64,36.64 83.84,36.84 v1(85.37,36.84) 86.19,36.84 v2(86.62,36.42) ; v1(85.47,68.44) 85.17,68.13 85.14,68.13 84.93,67.93 84.27,67.93 83.52,67.19 83.52,67.03 U5.R3
  TOP w0.267: R18.1 86.97,44.7 v1(86.64,45.03)
  IN1 w0.102: v1(83.6,55.69) 84.08,56.17 84.08,56.51 84.2,56.63 84.99,56.63 85.11,56.75 85.11,57.61 85.83,58.34 85.83,58.72 85.96,58.84 86.34,58.84 86.82,59.33 86.82,60.71 86.43,61.1 86.43,61.57 86.63,61.77 v1(86.63,62) 86.83,62.2 86.83,63.3 85.44,64.7 85.44,68.4 v1(85.47,68.44) ; v1(83.85,24.37) 83.85,24.53 86.1,26.78 86.1,29.43 86.47,29.8 86.47,31.62 v1(86.25,31.83) 85.83,32.25 85.83,33.37 86.01,33.55 86.35,33.55 86.48,33.67 86.48,33.91 86.34,34.05 85.74,34.05 85.37,34.42 v1(85.37,36.84)
  IN2 w0.089: 49.51,41.05 48.15,41.05 46.48,42.71 v1(44.53,42.71)
  IN2 w0.33: 49.51,41.05 50.58,41.05 56.11,35.53 59.45,35.53 59.82,35.9 59.82,36.62 60,36.8 61.62,36.8 62.63,37.81 63.51,37.81 64.38,36.94 67.11,36.94 68.52,38.34 68.52,42.23 69.49,43.2 72.83,43.2 73.47,43.83 75.4,43.83 76.04,44.48 83.79,44.48 84.37,45.07 86.06,45.07 86.11,45.03 v1(86.64,45.03)
  BOTTOM w0.089: v1(44.53,42.71) 43.9,43.34 42.01,43.34 41.88,43.48 41.73,43.48 41.45,43.76 U1.AU40
  BOTTOM w0.102: v1(86.63,62) 86.43,61.81 86.43,57.82 86.87,57.39 86.87,54.45 86.49,54.07 86.49,45.18 v1(86.64,45.03) 86.6,44.99 86.6,35.45 86.5,35.35 85.74,35.35 85.64,35.25 85.64,35.05 85.74,34.95 86.56,34.95 86.67,34.85 86.67,34.21 86.56,34.1 85.74,34.1 85.64,34 85.64,33.5 85.83,33.31 85.83,32.78 85.61,32.56 85.61,32.17 85.42,31.97 85.42,31.59 85.55,31.46 85.76,31.46 86.13,31.83 v1(86.25,31.83)
M_CHA_MAA10: length 135.4
  TOP w0.102: U2.L7 79.98,27.01 v1(79.58,27.41) ; U3.L7 79.98,37.99 v1(80.06,37.91) ; v1(79.58,58.76) 79.98,58.36 U4.L7 ; U5.L7 v1(79.98,68.78)
  TOP w0.267: v1(78.67,51.53) 79,51.53 79.69,50.83 R19.1
  IN1 w0.102: v1(80.06,37.91) 80.06,40.12 79.91,40.28 78.82,40.28 78.72,40.17 78.72,39.82 78.82,39.72 79.07,39.72 79.15,39.64 79.15,38.72 78.87,38.44 v1(78.87,35.88) 78.96,35.79 78.96,32.61 78.83,32.48 78.83,28.15 v1(79.58,27.41) ; v1(79.58,58.76) 79.39,58.56 79.12,58.56 79.05,58.49 79.05,58.32 78.96,58.23 78.72,58.23 78.6,58.35 78.6,58.95 78.73,59.07 79.06,59.07 79.19,59.2 79.19,59.4 79.06,59.53 78.73,59.53 78.6,59.66 78.6,59.96 78.73,60.09 79.04,60.09 79.16,60.22 79.16,60.44 79.04,60.57 78.73,60.57 78.6,60.7 78.6,60.89 78.73,61.01 79.01,61.01 79.33,61.33 79.33,61.53 79.16,61.69 79.16,61.99 79.03,62.12 v1(78.59,62.12) 78.99,62.52 78.99,64.09 78.69,64.38 78.69,67.49 v1(79.98,68.78)
  IN2 w0.089: 49.51,53.55 46.85,53.55 44.78,51.48 43.89,51.48 40.51,48.1 39.9,48.1 39.6,47.79 v1(39.6,47.54)
  IN2 w0.33: 49.51,53.55 52.53,53.55 53.61,54.63 54.79,54.63 58.49,58.33 63.62,58.33 64.57,59.28 67.26,59.28 67.87,58.67 70.21,58.67 70.62,58.26 73.71,58.26 74.45,57.52 74.45,56.39 74.94,55.9 77.12,55.9 77.45,55.57 77.45,52.38 78.31,51.52 78.65,51.52 v1(78.67,51.53)
  BOTTOM w0.089: U1.AP35 39.6,47.3 39.6,47.46 39.6,47.47 v1(39.6,47.54)
  BOTTOM w0.102: 75.41,51.4 v2(75.41,51.4) ; 75.41,51.4 78.54,51.4 v1(78.67,51.53) 78.43,51.77 78.22,51.77 78.11,51.88 77.65,51.88 77.55,51.99 77.55,52.21 77.65,52.32 78,52.32 78.13,52.45 78.13,52.74 78.26,52.87 78.26,53.13 78.36,53.23 78.74,53.23 78.82,53.31 78.82,53.44 78.72,53.54 78.36,53.54 78.26,53.65 78.26,55.29 78.38,55.4 78.38,56.13 78.27,56.23 77.54,56.23 77.43,56.33 77.43,56.71 77.54,56.81 78.45,56.81 78.55,56.91 78.55,57.25 78.14,57.66 77.76,57.66 77.64,57.78 77.64,58.15 77.33,58.46 77.33,58.59 77.23,58.69 76.89,58.69 76.8,58.78 76.8,59.17 76.9,59.28 77.23,59.28 77.33,59.38 77.33,60.69 77.7,61.06 77.95,61.06 78.15,61.26 78.15,61.9 77.92,62.13 76.85,62.13 76.75,62.23 76.75,62.43 76.85,62.53 77.12,62.53 77.22,62.63 77.22,62.83 77.12,62.93 76.85,62.93 76.75,63.03 76.75,63.27 76.85,63.37 78.75,63.37 79.1,63.03 79.1,62.27 78.94,62.12 v1(78.59,62.12) ; 75.41,51.4 73.27,49.26 73.27,42.65 74.74,41.18 75.89,41.18 76.16,40.91 76.16,40.9 76.89,40.17 78.14,40.17 78.4,39.92 78.4,38.01 78.66,37.75 78.66,36.09 v1(78.87,35.88)
M_CHA_MAA11: length 131.4
  TOP w0.102: v1(85.38,37.51) 84.7,38.2 83.52,38.2 U3.R7 ; U2.R7 83.5,27.01 83.95,26.55 84.74,26.55 v1(84.84,26.46) ; v1(84.54,69.11) 84.54,69.46 84.46,69.54 83.28,69.54 83.18,69.64 U5.R7 ; v1(84.65,57.9) 84.44,58.11 84.28,58.11 84.18,58.01 84.18,57.52 84.08,57.41 83.85,57.41 83.75,57.52 83.75,58.1 83.64,58.21 83.64,58.36 83.54,58.46 83.29,58.46 U4.R7
  TOP w0.267: v1(86.18,44.14) 85.87,44.45 R20.1
  IN1 w0.102: v1(84.65,57.9) 85.02,57.9 85.62,58.5 85.62,59 85.7,59.07 86.28,59.07 86.62,59.41 86.62,60.37 86.44,60.55 86.04,60.55 85.93,60.65 85.93,60.8 86.03,60.9 86.16,60.9 86.23,60.97 86.23,61.79 86.15,61.87 86.15,62.36 v1(86.37,62.58) 86.15,62.79 86.15,63.65 85.31,64.5 85.06,64.75 85.06,69.02 84.96,69.11 v1(84.54,69.11) ; v1(85.38,37.51) 84.95,37.08 84.95,34.26 85.18,34.03 85.18,33.66 85.63,33.21 85.63,31.58 v1(86.05,31.16) 85.76,31.16 85.63,31.03 85.63,30.8 85.73,30.7 86.16,30.7 86.26,30.6 86.26,30.37 86.16,30.27 85.73,30.27 85.63,30.17 85.63,28.55 85.89,28.29 85.89,26.86 85.54,26.51 85.4,26.51 85.29,26.61 85.29,26.74 85.55,26.99 85.55,27.12 85.45,27.22 85.29,27.22 84.84,26.76 v1(84.84,26.46)
  IN2 w0.089: 49.51,40.01 48.68,40.01 46.91,41.78 43.68,41.78 v1(42.83,42.64)
  IN2 w0.33: v1(86.18,44.14) 85.49,43.44 76.48,43.44 75.83,42.79 73.9,42.79 73.26,42.16 70.29,42.16 69.56,41.43 69.56,37.91 66.65,35 62.03,35 61.52,34.49 55.67,34.49 50.15,40.01 49.51,40.01
  BOTTOM w0.089: v1(42.83,42.64) 42.49,42.97 U1.AW41
  BOTTOM w0.102: v1(86.05,31.16) v2(86.05,30.04) 86.05,29.18 85.95,29.07 85.31,29.07 85.21,29.18 85.21,32.05 85.41,32.25 85.41,32.65 85.63,32.86 85.63,33.21 85.44,33.4 85.44,35.47 85.55,35.58 86.16,35.58 86.27,35.7 86.27,36.18 86.18,36.27 v1(86.18,44.14) 86.18,54.07 86.66,54.55 86.66,57.24 86.21,57.7 86.21,62.42 v1(86.37,62.58)
M_CHA_MAA12: length 135.4
  TOP w0.102: v1(81.18,37.08) 81.18,37.08 81.41,36.85 81.54,36.85 81.61,36.92 81.61,37.43 81.71,37.53 81.71,37.96 81.58,38.09 U3.N7 ; v1(82.35,57.16) 81.58,57.93 U4.N7 ; U5.N7 81.74,69.89 81.84,69.79 81.84,69.08 81.74,68.98 81.5,68.98 81.41,68.89 v1(81.41,68.39) ; U2.N7 81.58,25.77 81.84,25.52 82.05,25.52 v1(82.3,25.77)
  TOP w0.267: R21.1 75.26,44.59 v1(75.31,44.54)
  IN1 w0.102: v1(81.41,68.39) 82.24,67.56 82.24,65.07 82.36,64.94 82.36,64.1 83.23,63.23 v1(83.23,62.55) 82.96,62.29 82.96,59.05 82.78,58.87 82.32,58.87 81.93,58.48 81.93,57.58 v1(82.35,57.16) ; v1(82.3,25.77) 82.22,25.85 82.22,26.53 82.69,27.01 82.69,31.85 v1(82.71,31.86) 82.21,32.36 82.21,36.43 82.07,36.57 81.69,36.57 v1(81.18,37.08)
  IN2 w0.089: v1(41.54,42.65) 42,43.11 46.33,43.11 47.88,41.57 49.51,41.57
  IN2 w0.33: v1(75.31,44.54) 73.44,44.54 72.63,43.73 69.29,43.73 68.07,42.51 68,42.44 68,41.19 67.82,41.01 66.65,41.01 66.47,40.84 66.47,40.12 66.65,39.94 67.77,39.94 67.95,39.77 67.95,38.51 67.77,38.33 61.74,38.33 61.25,38.82 60.5,38.82 60.33,38.65 60.33,37.86 58.51,36.05 56.32,36.05 50.8,41.57 49.51,41.57
  BOTTOM w0.089: U1.AU41 41.19,42.99 v1(41.54,42.65)
  BOTTOM w0.102: v1(83.23,62.55) 82.96,62.29 82.96,59.48 82.88,59.4 82.49,59.4 81.63,58.54 81.63,56.27 82.21,55.69 82.21,51.27 82.08,51.15 80.77,51.15 79.96,50.34 79.96,49.52 79.83,49.39 76.89,49.39 76.65,49.15 76.65,48.14 77.27,47.52 77.27,45.57 76.87,45.18 76.43,45.18 76.25,45.36 76.25,45.99 76.18,46.07 75.82,46.07 v2(75.57,45.82) 75.31,45.56 v1(75.31,44.54) 78.44,44.54 80.6,42.38 80.6,38.93 81.13,38.39 81.43,38.39 81.92,37.9 82.25,37.9 82.67,37.48 82.67,36.96 82.09,36.38 82.09,32.19 82.1,32.18 82.1,31.83 81.79,31.52 81.79,28.16 81.92,28.03 82.63,28.03 82.88,28.29 82.88,29.56 83.14,29.81 83.14,30.19 82.71,30.62 v1(82.71,31.86)
M_CHA_MAA13: length 129.4
  TOP w0.102: v1(85.86,66.43) 85.52,66.77 84.99,66.77 84.84,66.92 84.84,67.25 84.74,67.36 84.08,67.36 83.98,67.25 U5.T3 ; v1(84.63,55.62) 84.17,55.15 U4.T3 ; U3.T3 84.98,35.34 85.09,35.44 85.3,35.44 v1(85.86,36) ; U2.T3 84.55,24.38 v1(84.74,24.38)
  TOP w0.267: R22.1 88.3,49.34 v1(87.21,48.25)
  IN1 w0.102: v1(85.86,66.43) 85.86,64.78 86.01,64.63 87.17,64.63 87.28,64.53 87.28,64.1 87.38,64 87.71,64 87.81,63.9 87.81,63.59 87.71,63.49 87.38,63.49 87.28,63.39 87.28,62.94 87.38,62.84 v1(87.89,62.84) 87.27,62.22 87.27,59.07 85.62,57.42 85.62,56.61 v1(84.63,55.62) ; v1(85.86,36) 86.24,36.39 86.59,36.39 86.89,36.09 86.89,31.55 v1(87.11,31.34) 86.89,31.12 86.89,29.65 86.5,29.26 86.5,26.5 84.74,24.73 v1(84.74,24.38)
  IN2 w0.089: 49.51,52.89 46.76,52.89 45.09,51.22 44.1,51.22 40.69,47.82 40.48,47.82 v1(40.23,47.57)
  IN2 w0.33: v1(87.21,48.25) 84.25,51.21 79.14,51.21 78.92,51 78.08,51 77.01,52.07 77.01,54.88 76.47,55.41 74.81,55.41 72.64,57.58 66.99,57.58 66.44,57.04 66,57.04 65.74,57.29 64.39,57.29 64.1,57.58 58.54,57.58 55.22,54.26 55.22,53.87 54.76,53.41 53.15,53.41 52.63,52.89 49.51,52.89
  BOTTOM w0.089: v1(40.23,47.57) 40.23,47.27 U1.AR35
  BOTTOM w0.102: v1(87.11,31.34) 86.89,31.55 86.89,32.84 87.21,33.15 87.21,44.57 87.39,44.75 87.39,46.17 87.1,46.47 87.1,46.93 87.21,47.05 v1(87.21,48.25) 87.21,54.16 87.27,54.22 87.27,62.15 87.05,62.37 v2(87.05,62.81) 87.05,63.19 87.17,63.31 87.74,63.31 87.89,63.15 v1(87.89,62.84)
M_CHA_MAA14: length 135.2
  TOP w0.102: U4.T7 84.98,58.35 85.11,58.22 85.11,56.39 85.29,56.2 85.89,56.2 v1(86.08,56.4) ; U3.T7 84.31,38.87 v1(85.37,38.87) ; U2.T7 84.77,27.01 85.06,27.3 85.06,27.92 85.36,28.22 87.19,28.22 v1(87.63,28.67) ; U5.T7 84.35,69.89 84.36,69.88 85.32,69.88 v1(85.47,70.04)
  TOP w0.267: v1(87.96,44.1) 88.47,43.59 R23.1
  IN1 w0.102: v1(85.37,38.87) 86.29,39.79 87.15,39.79 87.3,39.64 87.3,33 v1(87.62,32.68) 87.88,32.43 88.42,32.43 88.5,32.35 88.5,32.07 88.39,31.97 87.94,31.97 87.83,31.86 87.83,31.6 87.93,31.5 88.27,31.5 88.37,31.4 88.37,31.2 88.27,31.09 87.93,31.09 87.83,30.99 87.83,28.86 v1(87.63,28.67) ; v1(85.47,70.04) 85.9,69.61 85.9,69.16 87.41,67.65 87.41,66.3 88.52,65.19 88.52,61.9 v1(87.89,61.28) 87.89,56.97 87.76,56.84 86.18,56.84 86.08,56.74 v1(86.08,56.4)
  IN2 w0.089: 49.46,38.97 49.17,38.97 46.93,41.21 v1(44.26,41.21)
  IN2 w0.33: v1(87.96,44.1) 86.78,42.92 76.69,42.92 75.24,41.47 74.05,41.47 73.61,41.03 73.61,40.45 66.28,33.11 63.31,33.11 62.73,32.53 56.16,32.53 49.72,38.97 49.46,38.97
  BOTTOM w0.089: U1.AV42 42.13,41.95 43.52,41.95 v1(44.26,41.21)
  BOTTOM w0.102: v1(87.62,32.68) 88.47,32.68 88.57,32.78 88.57,34.88 88.47,34.98 87.89,34.98 87.78,35.08 87.78,35.43 87.89,35.53 88.5,35.53 88.6,35.63 88.6,37.28 88.5,37.38 87.89,37.38 87.78,37.48 87.78,41.11 87.89,41.22 88.55,41.22 88.65,41.32 88.65,41.78 v2(88.97,42.09) 89.16,42.28 89.16,44.47 89.05,44.57 88.7,44.57 88.6,44.47 88.6,44.2 88.5,44.1 v1(87.96,44.1) 87.96,44.46 88.05,44.55 88.05,61.13 v1(87.89,61.28)
M_CHA_MAA15: length 135.4
  TOP w0.102: U4.M7 80.64,58.35 80.53,58.24 80.53,58.13 80.42,58.02 80.42,57.92 v1(80.65,57.69) ; U3.M7 80.64,38.54 80.52,38.66 80.52,38.82 80.64,38.94 v1(81.18,38.94) ; U2.M7 v1(80.78,26.45) ; U5.M7 v1(81.18,69.49)
  TOP w0.267: R24.1 74.33,42.4 v1(74.47,42.26)
  IN1 w0.102: v1(81.18,69.49) 80.98,69.49 80.48,68.99 80.48,68.52 80.36,68.39 80.36,64.11 81.33,63.13 v1(81.33,61.83) 81,61.83 80.9,61.74 80.9,61.6 81.05,61.44 81.05,60.17 80.43,59.55 80.43,59.28 80.56,59.15 81.04,59.15 81.16,59.03 81.16,58.86 81.04,58.74 80.56,58.74 80.43,58.62 80.43,58.31 80.56,58.18 80.99,58.18 81.12,58.06 81.12,57.82 80.99,57.69 v1(80.65,57.69) ; v1(81.18,38.94) 81.18,39.26 81.1,39.34 80.6,39.34 80.5,39.24 80.5,37.25 80.41,37.17 80.01,37.17 79.91,37.07 79.91,36.86 80.01,36.76 80.28,36.76 80.38,36.66 80.38,33.5 v1(80.7,33.19) 80.33,33.19 80.2,33.06 80.2,32.61 80.33,32.48 80.7,32.48 80.82,32.35 80.82,31.79 80.7,31.67 80.21,31.67 80.09,31.54 80.09,31.28 80.16,31.21 80.44,31.21 80.51,31.14 80.51,26.72 v1(80.78,26.45)
  IN2 w0.089: v1(43.65,41.16) 43.67,41.18 43.67,41.19 44.09,41.61 46.78,41.61 48.9,39.49 49.16,39.49
  IN2 w0.33: 49.16,39.49 49.94,39.49 56.38,33.05 57.54,33.05 57.72,33.23 57.72,33.79 57.9,33.97 58.42,33.97 58.6,33.79 58.6,33.23 58.78,33.05 59.29,33.05 59.46,33.23 59.46,33.79 59.64,33.97 60.17,33.97 60.35,33.79 60.35,33.23 60.53,33.05 62.38,33.05 62.56,33.23 62.56,34.3 62.74,34.47 66.9,34.47 71.66,39.23 71.67,39.23 71.99,39.55 71.99,40.12 71.81,40.3 71.15,40.3 70.82,39.97 70.44,39.97 70.19,40.22 70.19,40.9 70.37,41.08 71.77,41.08 72.29,41.6 73.44,41.6 74.1,42.26 v1(74.47,42.26)
  BOTTOM w0.089: U1.AU42 41.59,41.78 41.97,41.78 41.98,41.77 43.44,41.77 43.65,41.56 v1(43.65,41.16)
  BOTTOM w0.102: v1(80.7,33.19) 81.05,33.19 81.13,33.27 81.13,33.55 81.03,33.65 80.69,33.65 80.56,33.77 80.56,35.21 80.16,35.6 80.16,36.93 79.98,37.12 79.54,37.12 79.33,36.9 78.97,36.9 78.86,37.01 78.86,37.53 78.97,37.63 79.34,37.63 79.44,37.74 79.44,38.04 79.34,38.14 78.7,38.14 78.6,38.24 78.6,38.57 78.7,38.68 78.86,38.68 78.96,38.78 78.96,39.01 78.86,39.11 78.7,39.11 78.6,39.21 78.6,39.67 78.7,39.77 78.86,39.77 78.96,39.87 78.96,40.28 78.86,40.38 77.76,40.38 77.66,40.48 77.66,41.03 77.56,41.13 77.29,41.13 77.19,41.03 77.19,40.71 77.09,40.61 76.74,40.61 76.64,40.71 76.64,41.38 76.54,41.48 75.82,41.48 75.72,41.58 75.72,41.93 75.82,42.03 76.95,42.03 77.05,42.13 77.05,42.64 76.95,42.74 76.3,42.74 76.2,42.84 76.2,43.06 76.1,43.16 75.62,43.16 75.52,43.06 75.52,42.44 75.41,42.33 75.11,42.33 75.01,42.44 75.01,43.06 74.91,43.16 74.66,43.16 74.58,43.07 74.58,42.36 v1(74.47,42.26) 73.94,42.79 v2(73.94,42.94) 73.76,43.12 73.76,47.57 73.58,47.75 73.58,48.56 76.11,51.1 78.99,51.1 80.27,52.37 80.27,54.21 80.43,54.37 80.43,55.41 80.03,55.81 80.03,59.14 81.04,60.16 81.04,61.54 v1(81.33,61.83)
M_CHA_ODT0: length 69.1
  TOP w0.102: U4.J1 78.59,53.55 78.61,53.54 78.96,53.54 78.97,53.55 U4.K1 79.2,53.55 79.58,53.17 v1(79.58,53.13) 79.58,52.87 79.41,52.7 79.41,52.29 ; v1(79.58,64.69) 79.58,64.88 79.38,65.09 U5.K1 U5.J1 ; v1(80.39,22.61) 80.39,22.13 80.12,21.87 79.74,21.87 79.4,22.21 U2.K1 U2.J1 ; U3.J1 U3.K1 79.18,32.9 79.16,32.88 79.16,32.69 v1(78.21,31.74)
  TOP w0.267: R29.1 80.47,50.73 80.47,51.39 79.92,51.93 79.68,51.93 79.41,52.21 79.41,52.29
  IN3 w0.102: v1(78.21,31.74) 79.16,32.69 79.16,35.12 79.29,35.25 79.29,36.06 78.87,36.47 78.07,36.47 77.81,36.72 77.81,37.8 78.82,38.8 78.82,44.62 78.3,45.14 78.3,50.13 79.08,50.92 79.08,52.15 78.56,52.67 78.56,53.58 78.36,53.79 78.36,56.38 78.96,56.98 78.96,61.19 79.01,61.24 79.01,61.29 v1(79.58,61.87)
  BOTTOM w0.102: v1(79.58,53.13) 79.58,54.09 80,54.52 80,55.23 79.5,55.73 79.5,56.37 78.96,56.92 78.96,58.19 78.65,58.5 v2(78.65,59.05) 78.65,60.78 79.01,61.13 79.01,61.29 v1(79.58,61.87) 79.58,61.87 v1(79.58,64.69) ; v1(80.39,22.61) 79.91,23.09 79.91,24.59 79.4,25.1 79.4,26.06 78.31,27.15 78.31,29.41 78.82,29.91 78.82,31.12 78.21,31.73 v1(78.21,31.74)
M_CHA_RAS#: length 134.3
  TOP w0.102: v1(78.23,35.91) 78.23,36.21 77.91,36.54 77.67,36.54 77.47,36.34 77.47,35.95 78.08,35.34 U3.J3 ; U4.J3 78.38,55.16 78.38,55.79 v1(78.79,56.2) ; U5.J3 78.72,67.02 78.72,67.59 78.28,68.03 77.14,68.03 77.04,67.93 77.04,67.37 77.14,67.27 v1(77.85,67.27) ; v1(78.77,25.08) 78.77,24.9 78.38,24.51 78.38,23.82 U2.J3
  TOP w0.267: R6.1 82.95,50.23 v1(82.2,49.48)
  IN1 w0.102: v1(77.85,67.27) 78.44,66.69 78.44,64.23 78.68,63.98 78.68,62.87 v1(78.56,62.76) 78.17,62.36 78.17,60.82 78.4,60.58 78.4,56.73 78.28,56.61 77.98,56.61 77.85,56.48 77.85,56.3 77.95,56.2 v1(78.79,56.2) ; v1(78.23,35.91) 78.23,35.58 78.31,35.5 78.69,35.5 78.75,35.44 78.75,32.87 78.63,32.75 78.63,31.16 v1(78.39,30.91) 78.13,30.66 78.13,26.89 77.55,26.31 77.55,25.77 78.24,25.08 v1(78.77,25.08)
  IN2 w0.33: v1(43.96,47.39) 43.96,47.58 44.36,47.98 44.36,48.67 46.5,50.81 53.49,50.81 54.01,51.33 54.41,51.33 54.94,50.79 55.75,50.79 57.42,52.47 58.47,52.47 58.65,52.65 58.65,53.22 58.83,53.4 59.3,53.4 59.7,52.99 61.32,52.99 61.49,53.17 61.49,54.14 61.67,54.32 62.37,54.32 62.54,54.14 62.54,53.17 62.72,52.99 63.21,52.99 63.68,53.46 64.54,53.46 65.44,54.36 66.03,54.36 66.61,54.94 67.33,54.94 68.81,53.46 69.34,53.46 69.86,52.94 70.27,52.94 70.69,53.36 71.12,53.36 71.35,53.13 71.35,52.3 71.58,52.07 73.3,52.07 75.83,49.55 76.38,49.55 76.73,49.9 76.96,49.9 77.26,49.61 77.26,49.46 77.48,49.23 79.29,49.23 79.59,48.92 81.64,48.92 v1(82.2,49.48)
  IN3 w0.102: v1(78.56,62.76) 79.31,62.76 79.41,62.66 79.9,62.66 80.77,63.52 81.37,63.52 82.04,62.85 82.04,62.13 82.28,61.89 82.48,61.89 82.76,61.61 82.76,60.34 83.1,60 84.13,60 84.23,60.11 84.81,60.11 85.35,59.57 85.35,50.87 83.96,49.48 v1(82.2,49.48) 83.22,48.46 83.22,45.54 83.22,38.68 82.46,37.93 82.46,37.05 82.1,36.69 82.1,31.82 81.74,31.46 81.74,30.73 81.27,30.26 79.04,30.26 v1(78.39,30.91)
  BOTTOM w0.089: U1.AY34 43.14,47.78 43.53,47.39 v1(43.96,47.39)
  BOTTOM w0.102: v2(83.16,50.16) 82.87,50.16 v1(82.2,49.48)
M_CHA_WE#: length 129.9
  TOP w0.102: v1(80.8,25.79) 80.8,25.34 80.31,24.85 80.31,24.13 U2.L3 ; v1(80.65,56.86) 79.98,56.19 U4.L3 ; v1(79.71,35.83) 80.14,36.26 80.42,36.26 80.52,36.16 80.52,35.7 80.16,35.34 U3.L3 ; U5.L3 80.35,66.69 80.45,66.79 80.45,67.28 80.35,67.38 79.84,67.38 v1(79.61,67.14)
  TOP w0.267: R8.1 81.87,49.01 v1(81.36,49.52)
  IN1 w0.102: v1(80.8,25.79) 80.29,26.3 80.29,30.75 v1(79.61,31.44) 79.61,31.83 79.73,31.96 79.73,32.26 80,32.53 80,33.07 79.88,33.19 79.63,33.19 79.55,33.27 79.55,33.57 79.66,33.67 80.09,33.67 80.18,33.77 80.18,36.07 80.11,36.14 80.01,36.14 v1(79.71,35.83) ; v1(79.61,67.14) 80.01,66.74 80.01,64.13 80.2,63.93 80.2,63.11 80.31,63.01 80.65,63.01 80.75,62.91 80.75,62.12 v1(80.42,61.79) 80.84,61.37 80.84,60.24 80.23,59.64 80.23,57.27 v1(80.65,56.86)
  IN2 w0.089: 49.29,52.37 46.49,52.37 45.16,51.05 44.17,51.05 42.53,49.41 42.53,48.11 42.6,48.05 42.6,47.57 v1(42.81,47.36)
  IN2 w0.33: 49.29,52.37 52.85,52.37 53.36,52.89 55.63,52.89 55.96,53.21 55.96,54.26 56.97,55.27 58.4,55.27 58.58,55.45 58.58,56.89 58.76,57.06 60.19,57.06 60.37,56.89 60.37,56.66 60.55,56.48 62.4,56.48 62.69,56.77 65.53,56.77 65.78,56.52 66.66,56.52 67.2,57.06 68.38,57.06 68.56,56.89 68.56,55.93 68.73,55.76 69.31,55.76 69.68,56.13 70.36,56.13 70.59,55.9 71.46,55.9 71.64,56.08 71.64,56.84 71.81,57.02 72.55,57.02 76.25,53.31 76.25,52.74 75.94,52.43 75.94,51.64 76.23,51.35 76.99,51.35 77.87,50.47 79.14,50.47 79.35,50.69 81.18,50.69 81.36,50.51 v1(81.36,49.52)
  IN3 w0.102: v1(79.61,31.44) 80.52,31.44 81.62,32.53 81.62,41.4 81.84,41.62 81.84,46.95 82.23,47.34 82.23,48.21 81.36,49.09 v1(81.36,49.52) 81.36,50.79 81.46,50.89 82.75,50.89 82.86,50.79 82.86,50.26 82.96,50.16 83.54,50.16 83.64,50.26 83.64,50.79 83.75,50.89 84.95,50.89 85.05,50.99 85.05,56.61 84.95,56.71 84.23,56.71 84.13,56.81 84.13,59.69 84.03,59.8 81.7,59.8 81.6,59.9 81.6,60.12 81.13,60.59 81.13,60.8 81.12,60.8 81.12,61.09 v1(80.42,61.79)
  BOTTOM w0.089: v1(42.81,47.36) 42.81,47.72 42.74,47.78 U1.AW34
  BOTTOM w0.102: v1(79.61,67.14) 80.2,67.14 v2(80.32,67.02)
M_CHB_BA0: length 45.5
  TOP w0.089: 41.7,50.6 40.9,49.8 40.32,49.8 39.69,49.18 39.41,49.18 39.02,48.79 39.02,48.37 38.65,48.01 38.14,48.01 v1(37.75,47.62)
  TOP w0.165: v1(62.46,51.91) 62.46,52.21 62.61,52.36 63.38,52.36 63.78,51.96 64.02,51.96 64.2,52.14 64.2,52.79 64.01,52.98 63.05,52.98 62.91,53.12 60.66,53.12 60.11,53.66 59.75,53.66 59.16,53.07 59.16,52.72 59.01,52.57 58.63,52.57 58.42,52.78 57.53,52.78 57.32,52.57 56.92,52.57 56.71,52.78 56.24,52.78 56.07,52.61 56.07,52.45 55.9,52.28 55.57,52.28 55.41,52.45 55.41,52.61 55.23,52.8 54.81,52.8 54.66,52.65 54.66,52.42 54.54,52.29 54.26,52.29 54.08,52.11 53.47,52.11 53.26,51.9 51.3,51.9 51.18,51.78 50.24,51.78 50.12,51.9 49.15,51.9 49.03,51.78 47.73,51.78 47.5,52.01 47.02,52.01 46.79,51.78 46.31,51.78 46,52.09 45.51,52.09 45.39,51.97 45.39,51.58 45.29,51.48 44.71,51.48 44.53,51.3 44.53,50.84 44.38,50.69 43.96,50.69 43.79,50.86 v2(43.79,51.27) 43.79,51.66 43.61,51.83 43.28,51.83 43.05,51.6 43.05,50.77 42.89,50.6 42.51,50.6 42.29,50.82 41.91,50.82 41.7,50.6
  BOTTOM w0.089: v1(37.75,47.62) 37.75,47.39 U1.AL35
  BOTTOM w0.165: v1(62.46,51.91) 63.02,51.35 63.15,51.35 63.25,51.45 63.43,51.45 63.86,51.03 63.86,50.79 63.3,50.23 63.04,50.23 61.98,51.29 61.32,51.29 61.22,51.4 61.22,51.86 61.09,51.99 60.76,51.99 60.42,51.65 DIMM1.109
M_CHB_BA1: length 45.5
  TOP w0.089: 44.53,47.97 44.19,47.97 44.01,47.79 41.3,47.79 40.64,47.13 39.6,47.13 38.7,46.23 38.17,46.23 37.77,46.63 v1(37.77,46.63)
  TOP w0.165: 44.53,47.97 46.08,49.53 54.15,49.53 54.48,49.85 54.48,49.85 54.87,50.24 54.87,50.42 55.06,50.61 55.42,50.61 55.59,50.44 55.59,49.96 55.75,49.79 56.08,49.79 56.25,49.96 56.25,50.44 56.41,50.61 58.76,50.61 59.16,50.21 60.17,50.21 60.57,50.61 63.46,50.61 63.68,50.39 64.06,50.39 64.29,50.61 64.29,51 64.42,51.12 64.95,51.12 65.41,50.66 66.91,50.66 67.08,50.84 v2(67.08,51) 67.08,51.25 66.91,51.42 65.72,51.42 v1(65.25,51.88)
  BOTTOM w0.089: U1.AM36 37.77,46.53 37.77,46.63 v1(37.77,46.63)
  BOTTOM w0.165: DIMM1.108 66.3,51.35 65.74,50.79 65.28,50.79 64.01,52.06 64.01,52.34 63.48,52.87 63.48,53.33 63.68,53.54 63.87,53.54 64.81,52.6 64.81,52.35 65.25,51.91 v1(65.25,51.88)
M_CHB_BA2: length 42.2
  TOP w0.089: 45.94,39.81 45.46,39.33 v1(44.89,39.33)
  TOP w0.165: 45.94,39.81 46.55,39.81 46.71,39.97 48.26,39.97 48.63,39.6 48.63,39.12 49.25,38.5 57.06,38.5 57.86,39.29 v2(57.86,39.64) 58.2,39.64 58.62,40.05 59.28,40.05 60.3,41.08 60.3,41.55 60.68,41.93 60.94,41.93 61.67,41.19 61.9,41.19 62.12,41.41 62.12,41.73 61.09,42.76 v1(61.09,42.99)
  BOTTOM w0.089: U1.AU49 41.46,38.65 41.96,38.65 42,38.62 44.18,38.62 44.89,39.33 v1(44.89,39.33)
  BOTTOM w0.165: v1(61.09,42.99) 61.09,42.87 61.42,42.54 62.46,42.54 62.82,42.89 63.88,42.89 64.01,43.02 64.01,43.65 64.14,43.78 64.75,43.78 64.87,43.65 64.87,41.14 64.75,41.01 64.24,41.01 64.11,41.14 64.11,42 63.98,42.13 63.37,42.13 63.25,42 63.25,41.38 63.12,41.25 61.77,41.25 61.65,41.38 61.65,41.72 61.52,41.85 61.19,41.85 60.39,42.65 DIMM1.79
M_CHB_CAS#: length 45.8
  TOP w0.089: v1(38.41,48.58) 38.66,48.83 38.66,48.94 39.26,49.54 39.55,49.54 40.17,50.16 40.64,50.16 42.01,51.54 42.05,51.54
  TOP w0.165: v1(60.96,54.04) 62.13,54.04 62.31,54.22 62.99,54.22 63.4,53.81 65.1,53.81 65.36,54.07 66.34,54.07 67.5,55.23 67.5,55.5 67.04,55.95 66.68,55.95 66.48,55.75 66.48,55.35 65.97,54.84 65.05,54.84 64.68,54.47 63.78,54.47 63.3,54.96 v2(62.97,54.96) 62.14,54.96 61.95,54.77 60.66,54.77 60.47,54.58 59.48,54.58 58.79,53.89 58.42,53.89 58.17,53.64 57.71,53.64 57.48,53.87 56.95,53.87 56.73,53.64 56.7,53.64 56.69,53.64 54.42,53.64 53.73,52.95 53.12,52.95 52.91,52.74 48.8,52.74 48.68,52.62 47.88,52.62 47.75,52.75 44.45,52.75 44.26,52.56 43.07,52.56 42.05,51.54
  BOTTOM w0.089: U1.AM33 38.08,48.2 38.41,48.54 v1(38.41,48.58)
  BOTTOM w0.165: DIMM1.115 60.43,53.45 60.72,53.15 61.23,53.15 61.9,53.82 61.9,54.02 61.55,54.37 61.29,54.37 v1(60.96,54.04)
M_CHB_CKE0: length 27
  TOP w0.165: v1(42.83,37.92) 42.93,38.02 45.95,38.02 47.4,36.57 57.86,36.57 59.42,38.12 60.08,38.12 61.14,39.18 v2(61.49,39.18) 62.8,39.18 v1(63,39.39)
  BOTTOM w0.089: v1(42.83,37.92) 42.98,38.06 42.98,38.17 U1.AY49
  BOTTOM w0.165: v1(63,39.39) 63,39.96 62.28,40.68 60.83,40.68 60.67,40.85 DIMM1.73
M_CHB_CKE1: length 30.3
  TOP w0.165: v1(45.81,37.52) 47.02,36.31 57.97,36.31 59.45,37.79 60.25,37.79 60.25,37.79 61.05,37.79 62.06,38.8 66.19,38.8 v2(67.04,39.65) 67.7,40.3 v1(67.7,40.48)
  BOTTOM w0.089: v1(45.81,37.52) 45.23,38.1 44.15,38.1 43.59,37.53 43.59,37.45 43.36,37.22 43.06,37.22 42.92,37.29 42.71,37.29 42.57,37.22 41.98,37.22 41.96,37.2 41.39,37.2 U1.AU50
  BOTTOM w0.165: v1(67.7,40.48) DIMM1.74
M_CHB_CLK0: length 37
  TOP w0.089: 39.87,45.02 39.85,45.01 39.85,45 39.82,44.96 39.82,44.95 38.88,44.01 38.51,44.01 38.36,44.16 38.36,44.59 38.43,44.67 38.72,44.67 v1(38.73,44.66)
  TOP w0.102: 55.12,47.64 54.72,47.64 54.62,47.74 54.62,47.93 54.37,48.18 53.9,48.18 53.68,47.96 53.68,47.57 53.58,47.46 53.27,47.46 53.17,47.57 53.17,47.96 52.95,48.18 52.48,48.18 52.26,47.96 52.26,47.57 52.15,47.46 51.85,47.46 51.75,47.57 51.75,47.96 51.53,48.18 51.05,48.18 50.83,47.96 50.83,47.57 50.73,47.46 50.43,47.46 50.33,47.57 50.33,47.96 50.11,48.18 49.63,48.18 49.41,47.96 49.41,47.57 49.31,47.46 49,47.46 48.9,47.57 48.9,47.96 48.68,48.18 46.69,48.18 46.43,47.92 46.43,47.19 46.35,47.1 45.71,47.1 45.49,46.88 45.49,46.19 45.19,45.89 44.73,45.89 44.26,45.42 43.42,45.42 43.36,45.36 40.96,45.36 40.91,45.31 40.15,45.31 39.87,45.02 ; 55.12,47.64 55.48,47.64 55.63,47.79 55.63,47.98 55.83,48.18 57.3,48.18 57.68,47.79 58.11,47.79 59.15,48.84 59.84,48.84 59.89,48.79 61.41,48.79 61.62,49 61.62,49.11 v1(61.39,49.34) ; 55.12,47.64 v2(55.12,47.93)
  BOTTOM w0.102: v1(38.73,44.66) 38.51,44.88 38.51,45.13 38.55,45.17 U1.AN38 ; DIMM1.101 60.61,49.25 61.34,49.98 61.51,49.98 61.7,49.79 61.7,49.64 v1(61.39,49.34)
M_CHB_CLK0#: length 37.3
  TOP w0.089: v1(37.82,44.72) 38.18,44.37 38.18,44.09 38.43,43.83 38.95,43.83 40,44.88 40,44.89
  TOP w0.102: 50.57,47.26 50.34,47.26 50.12,47.48 50.12,47.87 50.02,47.97 49.72,47.97 49.61,47.87 49.61,47.48 49.39,47.26 48.92,47.26 48.7,47.48 48.7,47.87 48.6,47.97 48.16,47.97 48.15,47.99 46.77,47.99 46.62,47.84 46.62,47.11 46.43,46.91 45.79,46.91 45.68,46.8 45.68,46.12 45.27,45.7 44.81,45.7 44.34,45.23 43.5,45.23 43.44,45.17 41.04,45.17 40.98,45.11 40.23,45.11 40,44.89 ; 50.57,47.26 50.82,47.26 51.04,47.48 51.04,47.87 51.14,47.97 51.44,47.97 51.54,47.87 51.54,47.48 51.77,47.26 52.24,47.26 52.46,47.48 52.46,47.87 52.56,47.97 52.87,47.97 52.97,47.87 52.97,47.48 53.19,47.26 53.66,47.26 53.88,47.48 53.88,47.87 53.98,47.97 54.29,47.97 54.41,47.85 54.41,47.66 54.64,47.44 55.57,47.44 55.57,47.44 55.84,47.71 55.84,47.9 55.91,47.97 57.22,47.97 57.6,47.59 58.19,47.59 59.23,48.63 59.75,48.63 59.8,48.58 61.49,48.58 61.83,48.91 61.83,49.12 v1(62.05,49.34) ; 50.57,47.26 v2(50.57,46.97)
  BOTTOM w0.102: U1.AM38 38.08,44.98 v1(37.82,44.72) ; v1(62.05,49.34) 61.9,49.5 61.9,49.88 61.6,50.18 61.26,50.18 60.93,49.85 DIMM1.103
M_CHB_CLK1: length 35.3
  TOP w0.102: v1(66.24,49.34) 66.07,49.52 66.07,49.78 65.88,49.97 64.85,49.97 ; 64.85,49.97 v2(64.85,50.26) ; 64.85,49.97 64.58,49.97 63.91,49.29 63.51,49.29 63.43,49.37 63.43,49.67 63.13,49.97 60.92,49.97 60.5,49.55 58.8,49.55 58.14,48.89 46.42,48.89 44.5,46.97 43.03,46.97 42.65,46.6 42.61,46.55 41.24,46.55 41.01,46.32 39.94,46.32 39.88,46.27 39.24,46.27 38.94,45.97 38.94,45.54 38.73,45.33 37.62,45.33 v1(37.19,45.76)
  BOTTOM w0.102: v1(37.19,45.76) 37.19,45.56 37.43,45.32 U1.AL38 ; DIMM1.102 66.88,49.55 66.68,49.75 66.5,49.75 66.24,49.5 v1(66.24,49.34)
M_CHB_CLK1#: length 35.6
  TOP w0.102: 57.86,48.68 v2(57.86,48.39) ; 57.86,48.68 58.23,48.68 58.89,49.34 60.58,49.34 61,49.76 63.05,49.76 63.23,49.59 63.23,49.29 63.43,49.09 63.99,49.09 64.67,49.76 65.79,49.76 65.86,49.69 65.86,49.6 v1(65.61,49.34) ; 57.86,48.68 48.16,48.68 48.15,48.7 46.5,48.7 44.58,46.78 43.11,46.78 42.79,46.46 42.69,46.36 41.32,46.36 41.09,46.13 40.01,46.13 39.96,46.08 39.32,46.08 39.13,45.89 39.13,45.46 38.81,45.14 37.48,45.14 v1(37.11,44.77)
  BOTTOM w0.102: U1.AK38 36.78,45.1 v1(37.11,44.77) ; DIMM1.104 66.78,50.15 66.59,49.95 66.41,49.95 66.23,49.77 66.03,49.77 v1(65.61,49.34)
M_CHB_CS#0: length 35.8
  TOP w0.089: v1(37.8,48.56) 37.68,48.67 37.68,50.1 37.93,50.35 40.55,50.35 43.01,52.81 43.39,52.81
  TOP w0.165: 43.39,52.81 44.15,52.81 44.64,53.29 48.4,53.29 48.52,53.41 52.59,53.41 53.76,54.58 55.04,54.58 55.31,54.31 55.86,54.31 56.13,54.58 58.53,54.58 59.2,55.25 60.19,55.25 60.38,55.44 v2(60.83,55.44) 61.68,55.44 61.88,55.64 63.3,55.64 63.43,55.77 64.11,55.77 64.27,55.61 v1(64.27,55.61)
  BOTTOM w0.089: U1.AM32 38.08,48.87 37.8,48.59 v1(37.8,48.56)
  BOTTOM w0.165: DIMM1.114 66.83,53.15 64.37,55.61 v1(64.27,55.61)
M_CHB_CS#1: length 33.5
  TOP w0.089: v1(37.15,48.56) 37.48,48.89 37.48,50.15 37.86,50.53 40.48,50.53 43.02,53.07
  TOP w0.165: v1(61.49,55.9) 61.49,56.23 61.29,56.43 60.66,56.43 60.53,56.3 60.53,56.08 59.96,55.51 59.1,55.51 58.42,54.83 57.22,54.83 57.02,55.04 57.02,55.73 56.82,55.92 55.96,55.92 55.81,55.77 55.81,55.06 v2(55.6,54.86) 53.67,54.86 52.48,53.67 48.41,53.67 48.29,53.55 44.53,53.55 44.05,53.07 43.02,53.07
  BOTTOM w0.089: U1.AK32 36.96,48.8 36.96,48.75 v1(37.15,48.56)
  BOTTOM w0.165: DIMM1.121 60.44,55.25 61.09,55.9 v1(61.49,55.9)
M_CHB_DQ0: length 49.3
  TOP w0.102: v1(51.92,24.81) 51.72,24.6 51.72,24.47 52.15,24.03 52.3,24.03 52.4,24.13 52.54,24.13 52.69,23.99 52.69,23.84 52.58,23.74 52.58,23.6 53.21,22.97 58.54,22.97 59.79,21.73 59.79,21.14 60.31,20.62 60.45,20.62 60.61,20.77 62.07,20.77 62.55,20.29 64.37,20.29 v2(64.53,20.12) v1(65.3,19.35)
  BOTTOM w0.089: U1.AY31 43.48,49.03 43.56,48.95 44.29,48.95 46.94,46.3
  BOTTOM w0.102: v1(51.92,24.81) 50.97,25.76 50.48,25.76 50.06,26.18 50.06,27.43 49.2,28.29 49.2,45.1 48,46.3 46.94,46.3 ; v1(65.3,19.35) 66.3,18.35 DIMM1.6
M_CHB_DQ1: length 50.1
  TOP w0.102: v1(64.44,19.35) 63.83,19.96 62.42,19.96 61.94,20.44 60.74,20.44 60.59,20.29 60.18,20.29 59.46,21 59.46,21.59 58.4,22.64 53.07,22.64 51.04,24.67 51.04,25.1 50.62,25.52 v2(50.29,25.52) 49.66,25.52 49.35,25.82 49.35,26.23 v1(49.58,26.46)
  BOTTOM w0.089: U1.AW31 42.63,49.03 42.77,48.89 43.08,48.74 43.5,48.74 43.52,48.77 44.21,48.77 47.01,45.97
  BOTTOM w0.102: DIMM1.4 66.27,17.75 64.67,19.35 v1(64.44,19.35) ; 47.01,45.97 47.86,45.97 48.87,44.96 48.87,28.16 49.73,27.29 49.73,26.61 v1(49.58,26.46)
M_CHB_DQ2: length 49.6
  TOP w0.102: v1(65.68,21.84) 65.68,22.68 65.41,22.95 65.02,22.95 64.91,22.85 64.91,22.55 64.81,22.45 64.61,22.45 64.51,22.55 64.51,22.85 64.41,22.95 64.2,22.95 64.1,22.85 64.1,22.55 64,22.45 63.8,22.45 63.69,22.55 63.69,22.85 63.59,22.95 62.84,22.95 v2(62.67,23.12) 62.13,23.67 60.79,23.67 59.4,25.06 55.55,25.06 55.45,25.16 55.45,25.4 55.62,25.57 55.95,25.57 56.14,25.76 v1(56.14,25.99)
  BOTTOM w0.089: 47.75,48.38 46.48,48.38 44.35,50.51 43.27,50.51 U1.AY29
  BOTTOM w0.102: DIMM1.16 66.17,21.35 v1(65.68,21.84) ; 47.75,48.38 48.86,48.38 51.28,45.96 51.28,30.28 54.29,27.28 54.86,27.28 v1(56.14,25.99)
M_CHB_DQ3: length 50.5
  TOP w0.102: v1(66.31,21.84) 66.31,20.7 66.45,20.57 66.75,20.57 66.91,20.72 v2(66.91,21.23) 66.91,22.17 65.79,23.28 63.91,23.28 63.2,24 60.93,24 59.54,25.39 57.05,25.39 56.82,25.62 v1(56.82,25.99)
  BOTTOM w0.089: 47.75,48.71 46.4,48.71 44.43,50.68 42.8,50.68 U1.AW29
  BOTTOM w0.102: v1(66.31,21.84) 66.42,21.95 DIMM1.18 ; v1(56.82,25.99) 55.21,27.61 54.43,27.61 51.61,30.42 51.61,46.1 49,48.71 47.75,48.71
M_CHB_DQ4: length 50.9
  TOP w0.102: v1(61.93,19.35) 62.16,19.58 62.16,19.73 61.77,20.11 60.96,20.11 60.88,20.02 60.88,19.55 60.77,19.45 60.55,19.45 58.98,21.01 58.98,21.16 59.13,21.31 59.13,21.45 58.99,21.59 58.84,21.59 58.69,21.45 58.55,21.45 58.41,21.59 58.41,21.73 58.55,21.88 58.55,22.03 58.41,22.17 58.27,22.17 58.12,22.02 57.98,22.02 57.68,22.31 52.93,22.31 51.38,23.87 v2(50.98,23.87) 49.54,23.87 49.3,24.11 49.3,24.27 49.46,24.43 50.37,24.43 50.5,24.55 v1(50.5,24.81)
  BOTTOM w0.089: 47.72,45.64 47.04,45.64 44.09,48.59 43.6,48.59 43.57,48.57 43.04,48.57 42.69,48.73 42.14,48.73 U1.AV31
  BOTTOM w0.102: v1(50.5,24.81) 48.54,26.76 48.54,44.82 47.72,45.64 ; DIMM1.7 61.23,18.65 v1(61.93,19.35)
M_CHB_DQ5: length 51.4
  TOP w0.102: v1(62.66,19.35) 62.18,18.86 60.67,18.86 57.55,21.98 52.8,21.98 51.44,23.33 49.61,23.33 48.74,24.2 v2(48.74,24.55) 48.74,24.81 49.02,25.09 49.51,25.09 v1(49.75,24.85)
  BOTTOM w0.089: 45.11,47.18 44.49,47.81 44.03,47.81 44.01,47.79 43.65,47.79 43.37,48.08 43.02,48.08 42.99,48.06 42.64,48.06 42.62,48.08 42.31,48.08 42.29,48.06 42.04,48.06 41.84,48.25 41.84,48.56 41.64,48.76 41.46,48.76 U1.AU31
  BOTTOM w0.102: v1(62.66,19.35) 61.36,18.05 DIMM1.5 ; v1(49.75,24.85) 49.74,24.85 48.21,26.38 48.21,44.69 47.44,45.46 46.96,45.46 45.24,47.18 45.11,47.18
M_CHB_DQ6: length 50.8
  TOP w0.102: v1(62.18,22.35) 62.18,22.85 61.94,23.1 60.9,23.1 59.26,24.73 54.53,24.73 53.02,26.24 53.02,26.51 53.22,26.71 53.48,26.71 54.65,25.54 55.03,25.54 v1(55.48,25.99)
  BOTTOM w0.089: 47.75,48.05 46.56,48.05 44.28,50.33 43.69,50.33 43.45,50.09 43.08,50.09 43.03,50.12 42.97,50.14 42.97,50.15 42.93,50.17 42.71,50.17 42.56,50.09 42.43,50.09 42.12,50.24 42.09,50.27 U1.AV29
  BOTTOM w0.102: DIMM1.15 60.88,21.05 v1(62.18,22.35) ; v1(55.48,25.99) 54.76,26.71 v2(54.61,26.71) 54.38,26.71 50.95,30.14 50.95,45.82 48.72,48.05 47.75,48.05
M_CHB_DQ7: length 51.6
  TOP w0.102: v1(61.55,22.35) 61.13,22.77 60.76,22.77 59.13,24.4 54.34,24.4 52.38,26.36 52.38,26.6 51.87,27.11 51.87,27.45 v2(52.07,27.65) 52.3,27.88 52.9,27.88 v1(54.79,25.99)
  BOTTOM w0.089: 47.75,47.72 46.63,47.72 44.21,50.15 43.76,50.15 43.53,49.92 43.04,49.92 42.98,49.94 42.88,49.99 42.75,49.99 42.6,49.92 42.38,49.92 42.23,49.99 41.99,49.99 41.97,49.98 41.67,49.98 41.65,50 41.46,50 U1.AU29
  BOTTOM w0.102: v1(61.55,22.35) 60.85,21.65 DIMM1.17 ; v1(54.79,25.99) 54.32,25.99 52.83,27.47 52.83,27.66 50.62,29.87 50.62,45.69 48.59,47.72 47.75,47.72
M_CHB_DQ8: length 47.3
  TOP w0.102: v1(56.17,28.24) 56.17,27.93 56.5,27.61 59.59,27.61 61.15,26.04 v2(65.18,26.04) 66.02,26.04 66.28,25.79 66.28,25.32 66.14,25.18 65.76,25.18 65.66,25.08 v1(65.66,24.61)
  BOTTOM w0.089: 47.75,49.98 45.88,49.98 44.65,51.22 44.34,51.22 44.1,51.46 U1.AY27
  BOTTOM w0.102: v1(65.66,24.61) 65.69,24.61 66.55,23.75 DIMM1.24 ; v1(56.17,28.24) 56.17,28.53 55.89,28.81 55.45,28.81 55.16,29.1 54.78,29.1 52.88,31 52.88,46.62 49.52,49.98 47.75,49.98
M_CHB_DQ9: length 48.4
  TOP w0.102: v1(65.03,24.61) 65.03,24.28 64.64,23.89 64.16,23.89 63.96,24.1 v2(63.96,24.45) 63.96,24.84 64.34,25.21 64.34,25.57 64.2,25.71 61.01,25.71 59.45,27.28 56.37,27.28 55.54,28.1 v1(55.54,28.25)
  BOTTOM w0.089: 47.75,49.65 45.96,49.65 44.58,51.04 44.27,51.04 44.15,51.16 42.79,51.16 U1.AW27
  BOTTOM w0.102: DIMM1.22 66.49,23.15 v1(65.03,24.61) ; 47.75,49.65 49.39,49.65 52.55,46.49 52.55,30.86 54.7,28.72 55.07,28.72 v1(55.54,28.25)
M_CHB_DQ10: length 47.4
  TOP w0.102: v1(63.84,28.09) 63.86,28.09 63.86,28.64 62.73,29.77 62.17,29.77 62.07,29.67 62.07,29.34 61.98,29.25 61.68,29.25 61.58,29.35 61.58,29.66 61.46,29.77 61.16,29.77 61.07,29.68 61.07,29.35 60.97,29.25 60.66,29.25 60.56,29.35 60.56,29.66 60.45,29.77 56.98,29.77 56.63,30.12 v1(56.63,30.52)
  BOTTOM w0.089: 47.75,52.07 45.82,52.07 45.14,52.75 43.55,52.75 43.49,52.81 U1.AY25
  BOTTOM w0.102: DIMM1.35 60.66,27.05 62.28,28.67 63.27,28.67 63.86,28.09 v1(63.84,28.09) ; 47.75,52.07 50.39,52.07 54.97,47.49 54.97,37.91 v2(55.68,37.2) 55.68,36.42 56.01,36.09 56.01,33.59 56.63,32.98 v1(56.63,30.52)
M_CHB_DQ11: length 48.6
  TOP w0.102: v1(57.28,30.52) 57.28,30.27 57.44,30.1 63.01,30.1 64.13,28.98 v2(65.23,28.98) 65.68,28.98 65.82,28.84 65.82,27.64 65.49,27.31 65.05,27.31 64.85,27.11 v1(64.85,26.68)
  BOTTOM w0.089: 47.75,52.4 45.79,52.4 45.26,52.93 43.63,52.93 43.46,53.1 43.08,53.1 42.86,52.99 42.48,52.81 U1.AW25
  BOTTOM w0.102: v1(64.85,26.68) 65.32,26.2 65.89,26.2 66.44,26.75 DIMM1.34 ; 47.75,52.4 50.52,52.4 55.4,47.52 55.4,38.38 56.34,37.44 56.34,33.73 57.28,32.79 57.28,30.52 v1(57.28,30.52)
M_CHB_DQ12: length 48.6
  TOP w0.102: v1(54.68,28.22) v2(54.15,28.74) 53.73,29.17 53.33,29.17 53.05,28.88 53.05,28.6 55.03,26.62 59.18,26.62 60.76,25.04 62.03,25.04 v1(62.46,24.61)
  BOTTOM w0.089: U1.AV27 41.96,51.57 42.67,50.86 44.5,50.86 46.04,49.32 47.75,49.32
  BOTTOM w0.102: 47.75,49.32 49.25,49.32 52.22,46.35 52.22,30.68 v1(54.68,28.22) ; DIMM1.23 61.3,23.45 v1(62.46,24.61)
M_CHB_DQ13: length 49.7
  TOP w0.102: v1(55.36,30.54) 55.12,30.3 55.12,28.05 56.23,26.95 59.31,26.95 60.88,25.38 62.42,25.38 v1(63.19,24.61)
  BOTTOM w0.089: 47.75,51.41 45.87,51.41 44.9,52.37 43.57,52.37 43.54,52.35 43.03,52.35 42.88,52.42 42.76,52.42 42.59,52.35 42.39,52.35 42.25,52.41 42.17,52.43 41.39,52.43 41.19,52.23 U1.AU27
  BOTTOM w0.102: v1(55.36,30.54) 54.6,31.3 54.6,34.07 54.31,34.36 v2(54.31,34.76) 54.31,47.21 50.11,51.41 47.75,51.41 ; v1(63.19,24.61) 61.59,23 60.86,23 60.71,22.85 DIMM1.21
M_CHB_DQ14: length 48.7
  TOP w0.102: v1(63.21,28.06) 63.21,28.46 62.76,28.91 v2(62.49,28.91) 60.33,28.91 59.8,29.44 57.15,29.44 56.89,29.19 56.68,29.19 56.52,29.35 56.52,29.73 56.44,29.81 56.06,29.81 55.98,29.74 55.98,28.9 55.89,28.81 55.62,28.81 55.45,28.99 55.45,30 v1(55.99,30.55)
  BOTTOM w0.089: 47.75,51.74 45.79,51.74 44.98,52.55 43.49,52.55 43.47,52.53 43.08,52.53 42.92,52.6 42.72,52.6 42.55,52.53 42.43,52.53 42.12,52.67 U1.AV25
  BOTTOM w0.102: DIMM1.33 60.6,26.45 61.39,27.25 62.39,27.25 v1(63.21,28.06) ; v1(55.99,30.55) 55.99,33.14 55.68,33.46 55.68,35.81 54.64,36.85 54.64,47.35 50.25,51.74 47.75,51.74
M_CHB_DQ15: length 49.5
  TOP w0.102: v1(57.91,30.52) v2(63.3,30.52) 64.11,29.71 65.7,29.71 66.25,29.16 66.25,26.9 66.02,26.68 v1(65.51,26.68)
  BOTTOM w0.089: U1.AU25 41.49,53.11 42.57,53.11 42.9,53.21 43.04,53.27 43.53,53.27 43.7,53.1 45.34,53.1 45.71,52.73 47.75,52.73
  BOTTOM w0.102: v1(65.51,26.68) 66.18,27.35 DIMM1.36 ; v1(57.91,30.52) 57.91,32.62 56.67,33.87 56.67,37.57 55.73,38.51 55.73,47.66 50.66,52.73 47.75,52.73
M_CHB_DQ16: length 57.3
  TOP w0.102: v1(64.15,32.58) 64.33,32.4 v2(65.64,32.4)
  IN1 w0.089: v1(37.75,51) 37.27,50.51 36.96,50.51 36.2,49.75 36.12,49.75
  IN1 w0.127: v1(64.15,32.58) 64.64,33.07 64.64,33.24 64.39,33.49 64.21,33.49 63.81,33.09 63.05,33.09 61.91,34.23 60.56,34.23 59.71,35.08 58.84,35.08 57.99,35.93 57.99,36.49 57.83,36.65 47.27,36.65 47.07,36.85 47.07,37.33 46.89,37.51 46.56,37.51 46.38,37.33 46.38,36.9 46.13,36.65 45.91,36.65 45.69,36.43 41.82,36.43 41.27,36.98 40.19,36.98 39.06,38.11 36.25,38.11 34.32,40.05 34.32,48.98 35.08,49.75 36.12,49.75
  BOTTOM w0.089: v1(37.75,51) 37.75,50.78 U1.AM29
  BOTTOM w0.102: v1(64.15,32.58) 65.48,31.25 65.48,29.94 66.27,29.15 DIMM1.42
M_CHB_DQ17: length 58.3
  TOP w0.102: v1(63.52,32.56) 63.1,32.56 63.08,32.58 v2(62.56,32.58)
  IN1 w0.127: v1(63.52,32.56) 63.37,32.71 62.93,32.71 62.37,33.27 60.72,33.27 60.45,33.53 60.45,33.83 59.56,34.73 58.69,34.73 57.13,36.29 54,36.29 53.87,36.17 53.87,35.88 53.75,35.76 53.36,35.76 53.24,35.88 53.24,36.17 53.11,36.29 52.73,36.29 52.6,36.17 52.6,35.88 52.48,35.76 52.09,35.76 51.97,35.88 51.97,36.17 51.84,36.29 51.46,36.29 51.33,36.17 51.33,35.88 51.21,35.76 50.82,35.76 50.7,35.88 50.7,36.17 50.57,36.29 50.19,36.29 50.06,36.17 50.06,35.88 49.94,35.76 49.55,35.76 49.43,35.88 49.43,36.17 49.3,36.29 48.92,36.29 48.79,36.17 48.79,35.88 48.67,35.76 48.28,35.76 48.16,35.88 48.16,36.17 48.03,36.29 46.02,36.29 45.82,36.09 39.56,36.09 38.43,37.22 36.84,37.22 34.01,40.05 34.01,49.17 34.92,50.07 36.18,50.07 37.09,50.98 v1(37.1,50.98)
  BOTTOM w0.089: v1(37.1,50.98) 36.78,50.67 U1.AK29
  BOTTOM w0.102: DIMM1.40 66.5,28.55 66.25,28.8 65.46,28.8 64.26,29.99 64.26,31.81 v1(63.52,32.56)
M_CHB_DQ18: length 58.1
  TOP w0.102: v2(61.52,31.16) 62.28,31.92 v1(62.85,31.92)
  IN1 w0.127: v1(62.85,31.92) 62,31.92 61.88,32.05 61.88,32.48 61.8,32.55 61.29,32.55 61.17,32.44 60.54,32.44 60.26,32.72 59.74,33.24 59.74,33.54 59.27,34.02 58.4,34.02 57.43,34.98 56.75,34.98 56.62,35.11 56.62,35.45 56.49,35.58 56.11,35.58 55.98,35.45 55.98,35.11 55.86,34.98 46.02,34.98 45.9,34.87 44.04,34.87 43.64,35.27 36.12,35.27 33.33,38.07 33.33,49.34 35.29,51.3 35.94,51.3 36.86,52.23 37.34,52.23 37.76,51.81 v1(37.77,51.81)
  BOTTOM w0.089: v1(37.77,51.81) 37.43,51.47 U1.AL28
  BOTTOM w0.102: v1(62.85,31.92) 62.86,31.91 62.86,30.94 60.77,28.85 DIMM1.41
M_CHB_DQ19: length 58.4
  TOP w0.102: v1(63.48,31.92) 63.88,31.92 v2(65.08,30.73)
  IN1 w0.127: v1(63.48,31.92) 63.05,32.35 62.44,32.35 62.26,32.54 62.26,32.81 62.16,32.91 61.14,32.91 61.03,32.8 60.68,32.8 60.1,33.38 60.1,33.69 59.41,34.37 58.55,34.37 57.58,35.34 57.11,35.34 57,35.45 57,35.81 56.87,35.94 55.7,35.94 55.58,35.81 55.58,35.47 55.45,35.34 55.07,35.34 54.94,35.47 54.94,35.81 54.81,35.94 54.39,35.94 54.28,35.83 54.28,35.5 54.12,35.34 46.07,35.34 45.81,35.08 44.13,35.08 43.73,35.49 39.48,35.49 38.77,36.2 38.29,36.2 38.26,36.17 36.87,36.17 36.07,36.97 36.07,37.43 33.68,39.82 33.68,49.27 35.36,50.94 36.17,50.94 37.03,51.81 v1(37.11,51.81)
  BOTTOM w0.089: v1(37.11,51.81) 36.78,51.48 U1.AK28
  BOTTOM w0.102: v1(63.48,31.92) 63.48,31.07 60.66,28.25 DIMM1.39
M_CHB_DQ20: length 54.4
  TOP w0.102: v1(64.39,35.87) 64.14,36.13 v2(64.14,36.92)
  IN1 w0.089: 41.36,43.74 41.36,43.77 41.2,43.93 41.07,44.06 41.07,44.93 40.73,45.27 40.25,45.27 40.24,45.26 39.43,45.26 39.19,45.49 39.19,48.66 40.28,49.75 v1(40.28,50.94)
  IN1 w0.127: v1(64.39,35.87) 64.06,36.2 64.06,36.48 64.21,36.63 64.21,36.82 60.9,40.14 60.15,40.14 60,40.29 60,40.66 59.89,40.76 59.57,40.76 59.46,40.66 59.46,39.88 59.34,39.76 59.08,39.76 58.96,39.88 58.96,40.61 58.8,40.76 57.97,40.76 57.84,40.63 57.84,40.26 57.71,40.14 57.46,40.14 57.33,40.26 57.33,40.63 57.2,40.76 56.95,40.76 56.82,40.63 56.82,40.26 56.7,40.14 56.44,40.14 56.32,40.26 56.32,40.63 56.19,40.76 55.93,40.76 55.81,40.63 55.81,40.26 55.68,40.14 55.43,40.14 55.3,40.26 55.3,40.63 55.17,40.76 54.92,40.76 54.79,40.63 54.79,40.26 54.66,40.14 54.41,40.14 54.28,40.26 54.28,40.63 54.16,40.76 53.9,40.76 53.78,40.63 53.78,40.26 53.65,40.14 53.39,40.14 53.27,40.26 53.27,40.63 53.14,40.76 52.89,40.76 52.76,40.63 52.76,40.26 52.63,40.14 52.38,40.14 52.25,40.26 52.25,40.63 52.12,40.76 46.22,40.76 45.21,39.75 43.97,39.75 43.5,40.22 41.73,40.22 41.07,40.88 41.07,42.86 41.36,43.15 41.36,43.74
  BOTTOM w0.089: v1(40.28,50.94) 40.28,50.93 40.03,50.68 U1.AR29
  BOTTOM w0.102: DIMM1.52 66.18,32.15 64.61,33.72 64.61,35.66 v1(64.39,35.87)
