# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CHG_VCC1_D: length 1.3
  TOP w0.102: v2(143.21,40.99) 143.21,41.9 v1(143.49,42.18)
CHG_VCC_D: length 2.4
  TOP w0.254: v2(145.67,46.76) v1(144.94,46.76)
  BOTTOM w0.508: PR78.2 v1(144.94,46.76)
CK32KE: length 7.8
  BOTTOM w0.102: v2(145.57,73.61) X3.2 148.76,73.61 CKC6.1 150.02,73.81 U20.9
CK_33M_TPM: length 199.5
  TOP w0.102: v1(85.12,83.43) 85.12,84.19 85.7,84.78 85.7,88.39 84.4,89.69 67.24,89.69 66.88,89.32 66.28,89.32 65.91,89.69 52.81,89.69 49.86,86.73 48.11,86.73 44.76,83.38 44.76,83.15 42.92,81.32 42.37,81.32 41.75,80.71 40.97,80.71 38.3,78.04 38.3,77.56 37.16,76.42 37.16,74.83 CKC7.1 36.3,73.33 36.27,73.3 36.27,72.58 CKR5.2 ; v1(92.46,12.29) 93.66,12.29 96.08,9.87 100.64,9.87 102.57,11.79 102.57,12.46 104.6,14.5 106.77,14.5 109.63,17.36 109.63,18.95 111.8,21.12 117.31,21.12 120.22,24.04 120.22,31.72 v2(119.97,31.97) 120.65,32.66 120.65,33.8 123.62,36.77 127.36,36.77 127.62,36.51 U9.21
  BOTTOM w0.102: v1(85.12,83.43) 85.12,83.02 83.36,81.27 83.36,79.54 85.5,77.41 87.25,77.41 88.76,75.9 88.76,74.82 89.1,74.49 89.41,74.49 89.99,73.91 89.99,72.62 91.87,70.74 91.87,51.87 91.57,51.57 91.57,50.89 91.92,50.54 91.92,41.14 90.84,40.06 90.84,36.82 91.86,35.8 91.86,34.73 92.57,34.02 92.57,20.58 90.76,18.76 90.76,17.67 91.39,17.04 91.39,14.24 92.46,13.17 v1(92.46,12.29)
CK_100M_CPUXDP: length 111
  TOP w0.102: v1(50.47,6.98) 50.37,7.08 50.37,9.77 ; GR8.1 69.27,15.1 69.11,15.26 69.11,15.83 68.96,15.98 66.56,15.98 64.29,13.71 57.89,13.71 57.34,13.16 51.17,13.16 50.37,12.36 50.37,9.77 ; 50.37,9.77 v2(50.65,9.77)
  IN1 w0.127: v1(50.47,6.98) 50.47,7.41 50.4,7.48 50.18,7.48 50.05,7.61 50.05,8.72 49.18,9.59 44.78,9.59 40.74,13.63 35.84,13.63 34.96,12.76 17.57,12.76 15.77,14.55 15.77,15.82 14.28,17.31 14.28,17.95 13.64,18.58 13.08,18.58 12.35,19.32 12.35,20.21 12.93,20.79 12.93,23.18 12.24,23.87 12.24,26.13 13.77,27.65 13.77,28.47 13.06,29.18 13.06,37.9 11.62,39.34 11.62,44.25 14.29,46.92 18,46.92 v1(18.37,46.55)
  BOTTOM w0.089: U1.A35 20.51,47.16 20.43,47.24 20.15,47.24 19.91,47.01 18.92,47.01 18.85,46.93 18.85,46.63 18.77,46.55 v1(18.37,46.55)
CK_100M_CPUXDP#: length 111
  TOP w0.102: v2(49.85,11.35) 50.13,11.35 ; 50.13,11.35 50.13,7.35 v1(49.79,7) ; 50.13,11.35 50.13,12.46 51.07,13.4 57.24,13.4 57.79,13.95 64.19,13.95 66.46,16.22 GR11.1
  IN1 w0.127: v1(18.35,47.19) 14.17,47.19 11.35,44.36 11.35,39.23 12.79,37.79 12.79,29.07 13.5,28.35 13.5,27.76 11.98,26.24 11.98,23.76 12.66,23.07 12.66,20.9 12.08,20.32 12.08,19.21 12.97,18.32 13.53,18.32 14.01,17.84 14.01,17.2 15.51,15.71 15.51,14.44 17.46,12.49 35.07,12.49 35.95,13.37 40.63,13.37 44.67,9.33 49.07,9.33 49.79,8.61 v1(49.79,7)
  BOTTOM w0.089: v1(18.35,47.19) 19.84,47.19 20.08,47.42 20.5,47.42 20.98,46.95 U1.B35
CK_100M_LVDS: length 186.1
  TOP w0.102: v1(149.48,15.73) 149.9,15.31 151.86,15.31 152.29,15.74 152.29,16.1 ; 152.29,16.1 152.29,16.46 153.27,17.44 153.27,17.54 PR232.2 ; 152.29,16.1 v2(152.01,16.1)
  IN1 w0.127: v1(149.48,15.73) 149.08,15.34 148.45,15.34 146.62,17.17 139.65,17.17 139,17.82 131.2,17.82 130.56,17.18 107.24,17.18 105.97,15.92 105.97,13.91 102.53,10.47 98.67,10.47 95.28,13.86 92.64,13.86 88.83,10.05 86.59,10.05 85.04,8.5 84.18,8.5 83.63,9.05 72.05,9.05 71.5,8.5 66.7,8.5 65.67,7.47 60.8,7.47 60.12,8.15 56.08,8.15 55.14,9.09 52.05,9.09 49.93,11.21 45.71,11.21 41.72,15.19 35.09,15.19 34.58,14.69 29.19,14.69 28.56,15.31 24.7,15.31 23.74,14.36 19.14,14.36 18.4,15.09 18.4,16.44 15.9,18.94 15.9,19.75 15.06,20.59 15.06,26.74 15.37,27.05 15.37,40.66 17.63,42.92 19.15,42.92 v1(19.71,43.48)
  BOTTOM w0.114: v1(19.71,43.48) 19.71,43.63 20.17,44.09 20.61,44.09 20.96,44.44 U1.B39
CK_100M_LVDS#: length 186.2
  TOP w0.102: v2(150.17,14.79) 150.17,15.07 ; 150.17,15.07 v1(149.48,15.07) ; 150.17,15.07 151.96,15.07 152.53,15.64 152.53,16.36 153.51,17.34 153.51,17.59 PR231.2
  IN1 w0.127: v1(19.08,43.48) 18.78,43.18 17.52,43.18 15.1,40.77 15.1,27.16 14.8,26.85 14.8,20.48 15.64,19.64 15.64,18.83 18.14,16.33 18.14,14.98 19.03,14.09 23.85,14.09 24.81,15.05 28.45,15.05 29.08,14.42 34.69,14.42 35.2,14.93 41.61,14.93 45.6,10.94 49.81,10.94 51.94,8.82 55.03,8.82 55.97,7.88 60.01,7.88 60.69,7.21 65.78,7.21 66.81,8.23 71.61,8.23 72.16,8.78 83.52,8.78 84.07,8.23 85.16,8.23 86.7,9.78 88.94,9.78 92.75,13.59 95.17,13.59 98.56,10.2 102.64,10.2 106.24,13.8 106.24,15.81 107.35,16.92 130.67,16.92 131.31,17.56 138.89,17.56 139.54,16.9 146.51,16.9 148.34,15.07 v1(149.48,15.07)
  BOTTOM w0.114: v1(19.08,43.48) 19.49,43.89 19.68,43.89 20.08,44.29 20.36,44.29 U1.A39
CK_100M_LVDS#_R: length 6.5
  TOP w0.102: U6.31 158.2,20.32 158.01,20.51 157.89,20.51 157.7,20.32 154.37,20.32 153.65,19.6 153.48,19.6 153.34,19.47 153.34,19.22 153.42,19.14 153.59,19.14 PR231.1
CK_100M_LVDS_R: length 6.9
  TOP w0.102: 157.23,20.56 157.65,20.56 157.81,20.72 U6.30 ; 157.23,20.56 v2(157.23,20.84) ; 157.23,20.56 154.32,20.56 153.57,19.8 153.39,19.8 153.11,19.52 153.11,19.12 PR232.1
CK_100M_MSATA: length 133.6
  IN1 w0.127: v1(94.57,12.9) 94.57,11.04 93.83,10.31 92.53,9.01 87.07,9.01 85.27,7.21 74.75,7.21 73.98,6.43 60.09,6.43 59.56,6.96 55.59,6.96 54.51,8.04 51.61,8.04 51.6,8.06 51.53,8.06 49.42,10.16 45.08,10.16 41.09,14.15 35.62,14.15 34.78,13.31 18.25,13.31 16.75,14.81 16.75,16.59 13.5,19.85 13.5,26.66 14.31,27.47 14.31,29.35 13.9,29.76 13.9,33.57 14.21,33.88 14.21,41.1 17.48,44.37 v1(17.88,44.37)
  BOTTOM w0.089: v1(17.88,44.37) 18.04,44.52 18.04,44.82 18.27,45.05 18.72,45.05 18.98,44.8 20.07,44.8 20.36,45.09 20.83,45.09 21.01,45.27 21.3,45.27 21.6,45.57 U1.C37
  BOTTOM w0.102: 93.37,14.9 93.92,14.9 94.57,14.25 v1(94.57,12.9) ; 93.37,14.9 92.94,14.9 92.79,15.06 92.79,16.96 94.65,18.83 CONSATA.55 ; 93.37,14.9 v2(93.37,15.18)
CK_100M_MSATA#: length 133.5
  IN1 w0.127: v1(18.52,44.39) 18.06,43.93 17.43,43.93 14.48,40.99 14.48,33.77 14.16,33.46 14.16,29.87 14.58,29.46 14.58,27.36 13.77,26.55 13.77,19.96 17.02,16.71 17.02,14.92 18.36,13.58 34.67,13.58 35.51,14.42 41.2,14.42 45.19,10.43 49.53,10.43 51.64,8.32 51.71,8.32 51.73,8.31 54.62,8.31 55.7,7.23 59.67,7.23 60.2,6.7 73.86,6.7 74.64,7.47 85.16,7.47 86.96,9.28 92.42,9.28 93.64,10.49 94.3,11.15 94.3,12.55 94.23,12.61 93.95,12.9 v1(93.8,12.9)
  BOTTOM w0.089: U1.B38 21.4,45.09 21.08,45.09 20.9,44.91 20.44,44.91 20.14,44.62 18.9,44.62 18.65,44.87 18.34,44.87 18.21,44.75 18.21,44.59 18.42,44.39 v1(18.52,44.39)
  BOTTOM w0.102: v1(93.8,12.9) 93.96,12.9 94.32,13.26 94.32,14.15 93.82,14.66 92.84,14.66 92.54,14.96 92.54,16.76 ; 92.54,16.76 92.54,17.06 94.55,19.07 94.94,19.07 95.19,19.33 CONSATA.53 ; 92.54,16.76 v2(92.27,16.76)
CLK_DEBUG: length 68.7
  TOP w0.102: v1(38.79,77.82) 41.19,80.22 41.95,80.22 42.57,80.84 43.12,80.84 45.24,82.95 45.24,83.18 48.31,86.25 50.14,86.25 53.09,89.21 65.71,89.21 66.08,88.84 67.08,88.84 67.44,89.21 83.89,89.21 v2(85.12,87.98) 85.12,84.9 84.63,84.42 84.63,82.41 84.46,82.24 84.46,79.9 83.39,78.83 83.39,77.84 83.96,77.28 CON5.12
  BOTTOM w0.102: CKR4.2 38.58,76.67 38.2,77.06 38.2,77.39 37.9,77.69 37.9,78.05 CKC4.1 38.36,77.96 38.51,77.82 v1(38.79,77.82)
CLK_DEBUG_R: length 24
  TOP w0.089: 36.17,70.68 35.83,70.34 35.83,67.86 34.95,66.97 34.95,63.17 35.18,62.93 35.18,61.68 35.53,61.34 36.03,61.34 36.82,60.55 37.11,60.55 37.44,60.22 38.76,60.22 v1(39.8,59.19)
  TOP w0.102: 36.17,70.68 36.28,70.79 CKR5.1 36.83,72.25 36.83,72.71 37.29,73.17 37.29,73.75 37.67,74.13 v1(37.67,74.83)
  BOTTOM w0.089: U1.AP15 39.77,59.46 39.77,59.21 v1(39.8,59.19)
  BOTTOM w0.102: v2(37.64,76.93) 38.1,76.47 38.1,75.28 37.67,74.85 ; 37.67,74.85 37.73,74.78 CKR4.1 ; 37.67,74.85 v1(37.67,74.83)
CLK_KBCPCI: length 91.2
  TOP w0.102: CKR3.2 35.68,73.01 35.68,74.33 CKC3.1 35.13,75.25 34.95,75.42 34.95,75.79 35.21,76.04 35.64,76.04 36.34,76.74 36.8,76.74 37.82,77.76 37.82,78.24 40.77,81.19 41.55,81.19 42.17,81.81 42.72,81.81 44.25,83.33 44.25,84.29 47.19,87.24 49.61,87.24 52.54,90.17 85.79,90.17 v2(87.66,88.31) 89.66,86.3 93.09,86.3 94.18,87.39 95.25,87.39 95.81,86.83 95.81,84.98 96.34,84.45 96.34,84.07 95.91,83.63 95.61,83.63 95.37,83.39 95.37,82.75 95.67,82.44 98.71,82.44 99.77,81.37 100.61,81.37 100.94,81.04 101.51,81.04 102.29,80.27 v1(102.29,80.23)
  BOTTOM w0.102: U10.13 99.64,80.53 99.84,80.73 100.28,80.73 100.51,80.5 100.51,79.92 100.8,79.64 102.13,79.64 102.29,79.8 v1(102.29,80.23)
CLK_KBCPCI_PCH_R: length 16.7
  TOP w0.089: 35.65,70.68 35.65,67.92 34.77,67.05 34.77,63.09 35.01,62.86 35.01,61.04 35.52,60.53 36.18,60.53 v2(36.88,59.83) 37.1,59.61 38.77,59.61 v1(39.17,59.22)
  TOP w0.102: CKR3.1 35.65,71.29 35.65,70.68
  BOTTOM w0.089: v1(39.17,59.22) 39.17,59.42 U1.AN15
CLK_PCIE1_WLAN#_PCH: length 228.2
  IN1 w0.127: v1(179.17,54.02) 178.93,54.26 178.93,55.32 178.12,56.14 174.67,56.14 173.51,54.98 173.51,50.49 171.27,48.25 171.27,40.61 168.86,38.19 167.04,38.19 163.71,34.87 159.59,34.87 156.57,31.84 153.98,31.84 146.94,24.81 145.7,24.81 144.29,23.39 144.29,22.41 142.44,20.57 131.88,20.57 129.39,18.08 123.37,18.08 122.13,19.31 107.46,19.31 102.71,14.56 100.73,14.56 99.41,13.24 97.45,13.24 96.05,14.63 92.19,14.63 88.4,10.84 81.89,10.84 80.93,9.87 71.63,9.87 71.07,9.31 66.37,9.31 65.3,8.25 61.19,8.25 60.4,9.03 56.85,9.03 56.02,9.86 52.41,9.86 50.18,12.09 46.04,12.09 42.17,15.97 34.75,15.97 34.49,15.7 29.58,15.7 29.1,16.17 20.27,16.17 17.35,19.09 17.35,19.1 17.34,19.11 17.34,19.51 15.84,21.01 15.84,23.6 16.28,24.05 16.28,25.14 16.44,25.29 16.44,27.29 16.14,27.59 16.14,40.31 17.8,41.97 18.07,41.97 v1(18.52,42.41)
  BOTTOM w0.089: U1.B41 20.93,43.06 20.78,42.91 20.78,42.84 20.68,42.74 20.3,42.74 20.15,42.88 19.07,42.88 19.03,42.84 19.03,42.83 19.01,42.82
  BOTTOM w0.102: v1(179.17,54.02) 179.17,53.72 179.22,53.67 179.69,53.67 179.87,53.85 CONWIFI.49 ; v1(18.52,42.41) 18.72,42.61 18.81,42.61 19.01,42.82
CLK_PCIE1_WLAN_PCH: length 228.2
  IN1 w0.127: v1(178.49,54.35) 178.67,54.53 178.67,55.21 178,55.87 174.78,55.87 173.78,54.87 173.78,50.38 171.54,48.14 171.54,40.5 168.97,37.93 167.15,37.93 163.82,34.6 159.7,34.6 156.68,31.58 154.09,31.58 147.05,24.54 145.81,24.54 144.55,23.28 144.55,22.3 142.56,20.3 131.99,20.3 129.5,17.81 123.26,17.81 122.02,19.04 107.57,19.04 102.82,14.29 100.84,14.29 99.52,12.97 97.34,12.97 95.94,14.37 92.31,14.37 88.51,10.57 82.01,10.57 81.04,9.61 71.74,9.61 71.19,9.05 66.48,9.05 65.42,7.98 61.08,7.98 60.29,8.77 56.74,8.77 55.91,9.59 52.3,9.59 50.07,11.83 45.93,11.83 42.06,15.7 34.86,15.7 34.6,15.44 29.47,15.44 28.99,15.91 20.16,15.91 17.08,18.98 17.08,18.99 17.07,19 17.07,19.4 15.57,20.9 15.57,23.71 16.02,24.16 16.02,25.25 16.17,25.4 16.17,27.18 15.88,27.47 15.88,40.42 v1(17.86,42.4)
  BOTTOM w0.089: U1.A41 19,43.06 18.94,43.01 18.9,42.97 18.89,42.97 18.88,42.95
  BOTTOM w0.102: v1(17.86,42.4) 17.86,42.41 18.26,42.82 18.74,42.82 18.88,42.95 ; v1(178.49,54.35) 178.72,54.12 178.72,53.84 179.12,53.43 179.76,53.43 179.84,53.35 CONWIFI.47
CLK_PCIE2_WLAN#_PCH: length 224.6
  IN1 w0.127: v1(176.47,59.96) 176.85,59.58 176.85,58.91 175.51,57.57 175.01,57.57 172.82,55.39 172.82,53.26 171.79,52.23 171.36,52.23 170.68,51.54 170.68,47.05 168.29,44.66 168.29,40.29 163.42,35.42 159.21,35.42 156.14,32.35 153.36,32.35 147.13,26.12 141.7,26.12 136.87,21.29 129.65,21.29 128.22,19.85 105.36,19.85 100.65,15.14 89.85,15.14 87.7,13 87.17,13 85.58,11.41 81.67,11.41 80.73,10.47 64.09,10.47 63.93,10.32 60.04,10.32 59.4,10.95 53.08,10.95 51.41,12.62 46.44,12.62 42.56,16.49 34.36,16.49 34.1,16.24 30.29,16.24 29.84,16.69 25.31,16.69 24.91,17.09 21.79,17.09 16.75,22.13 16.75,23.72 17.87,24.84 17.87,25.33 17.5,25.7 17.5,27.33 16.65,28.19 16.65,32.81 17.18,33.35 17.18,39.04 18.51,40.37 19.83,40.37 20.18,40.72 20.18,41.23 19.93,41.48 19.5,41.48 19.28,41.7 19.28,42.23 v1(19.25,42.26)
  BOTTOM w0.089: v1(19.25,42.26) 19.65,42.66 20.06,42.66 20.15,42.56 20.83,42.56 21.01,42.74 21.28,42.74 21.6,43.06 U1.C41
  BOTTOM w0.102: v1(176.47,59.96) 176.75,59.96 177.24,60.46 179.41,60.46 180.01,59.86 180.01,59.85 CONWIFI.73
CLK_PCIE2_WLAN_PCH: length 224.5
  IN1 w0.127: v1(19.89,42.26) 19.55,41.91 19.55,41.81 19.61,41.75 20.04,41.75 20.45,41.34 20.45,40.61 19.94,40.1 18.62,40.1 17.45,38.93 17.45,33.24 16.92,32.7 16.92,28.3 17.77,27.45 17.77,25.81 18.14,25.44 18.14,24.73 17.02,23.61 17.02,22.24 21.9,17.36 25.02,17.36 25.42,16.96 29.95,16.96 30.41,16.5 33.99,16.5 34.24,16.76 42.67,16.76 46.55,12.88 51.53,12.88 53.19,11.22 59.51,11.22 60.15,10.58 63.82,10.58 63.98,10.74 80.62,10.74 81.56,11.68 85.47,11.68 87.06,13.26 87.59,13.26 89.74,15.41 100.53,15.41 105.25,20.12 128.11,20.12 129.54,21.56 136.76,21.56 141.58,26.38 147.02,26.38 153.25,32.62 156.02,32.62 159.1,35.69 163.31,35.69 168.02,40.4 168.02,44.77 170.41,47.16 170.41,51.66 171.25,52.49 171.68,52.49 172.56,53.37 172.56,55.5 174.9,57.84 175.4,57.84 176.58,59.02 176.58,59.43 176.48,59.53 176.18,59.53 v1(175.79,59.15)
  BOTTOM w0.089: U1.B42 21.31,42.5 21.25,42.56 21.08,42.56 20.91,42.38 20.02,42.38 v1(19.89,42.26)
  BOTTOM w0.102: v1(175.79,59.15) 176.18,59.53 176.66,59.53 177.34,60.22 179.31,60.22 179.66,59.87 179.66,59.76 179.45,59.55 179.45,59.43 179.53,59.35 CONWIFI.71
CLK_PCIE_CR: length 52.3
  IN1 w0.127: v1(19.15,45.2) 19.15,46.24 18.89,46.51 18.89,47.53 17.92,48.5 17.92,53.35 12.38,58.89 12.38,61.62 13.21,62.45 13.21,66.26 10.54,68.93 6.55,68.93 1.47,74.01 1.47,83 1.73,83.25 2.16,83.25 v1(2.29,83.39)
  BOTTOM w0.089: U1.A37 20.14,45.57 20.08,45.64 19.59,45.64 v1(19.15,45.2)
  BOTTOM w0.102: CON10.43 2.43,83.24 v1(2.29,83.39)
CLK_PCIE_CR#: length 52.2
  IN1 w0.127: v1(19.81,45.2) 19.42,45.59 19.42,46.35 19.15,46.62 19.15,47.64 18.19,48.61 18.19,53.46 12.65,59 12.65,61.51 13.48,62.34 13.48,66.37 10.65,69.19 6.67,69.19 1.74,74.12 1.74,82.89 1.84,82.99 2.12,82.99 2.31,82.8 v1(2.31,82.54)
  BOTTOM w0.089: U1.B37 20.97,45.57 20.67,45.27 19.89,45.27 v1(19.81,45.2)
  BOTTOM w0.102: v1(2.31,82.54) 2.52,82.74 CON10.44
CLK_REQ0#: length 8.3
  BOTTOM w0.089: U1.U2 29.67,67.47 29.67,69.11 29.54,69.23 29.54,69.71 v2(29.39,69.87) 29.39,70.65
  BOTTOM w0.102: R84.1 29.7,74.38 29.5,74.18 29.5,73.27 29.06,72.83 29.06,71.49 29.39,71.16 29.39,70.65
CLK_REQ1_WLAN#: length 209.7
  TOP w0.089: v1(31.16,65.46) 30.41,66.21 30.41,68.93
  TOP w0.102: v1(91.47,86.91) 87.72,90.65 52.28,90.65 49.76,88.13 v2(45.8,88.13) 45.73,88.19 28.89,88.19 28.67,87.97 28.67,86.43 29.83,85.27 29.83,84.55 29.69,84.42 29.69,82.62 29.32,82.25 29.32,81.63 29.19,81.49 29.19,79.01 30.48,77.72 30.48,76.28 30.33,76.13 30.33,74.83 31.14,74.02 31.5,74.02 31.66,73.86 31.66,73.36 31.32,73.02 R80.2 29.99,72.43 29.99,71.7 R85.1 30.41,71.27 30.41,68.93
  IN1 w0.102: v1(178.77,59.76) 178.77,60.77 180.52,62.53 180.52,66.66 175.08,72.1 v1(168.71,72.1)
  IN2 w0.102: v1(91.47,86.91) 91.97,87.42 93.58,87.42 93.87,87.13 97.79,87.13 99,85.92 112.91,85.92 114.99,83.84 119.64,83.84 120.23,84.43 130.15,84.43 131.1,85.39 133.8,85.39 134.29,85.88 140.33,85.88 141.63,84.59 142.85,84.59 145.87,81.56 164.91,81.56 168.25,78.22 168.25,75.02 168.71,74.57 v1(168.71,72.1)
  BOTTOM w0.089: v1(31.16,65.46) 31.32,65.46 U1.Y5
  BOTTOM w0.102: v1(178.77,59.76) 178.31,59.3 178.31,55.9 179.17,55.03 179.68,55.03 179.86,54.85 CONWIFI.53
CLK_REQ2#: length 7.9
  BOTTOM w0.089: U1.AD1 33.48,68.05 33.48,68.1 32.88,68.7
  BOTTOM w0.102: 32.88,68.7 32.88,69.65 33.53,70.3 33.53,70.53 33.86,70.86 34.29,70.86 34.95,71.52 R400.1 35.41,72.06 35.41,73.01 35.47,73.07 R83.1
CLK_REQ4#: length 8.7
  TOP w0.089: v1(30.19,64.75) 30.66,65.22 30.66,65.57 30.2,66.03 30.2,69.23 29.87,69.56 v2(29.87,70.2) 29.87,70.97 R79.1
  TOP w0.102: R401.1 R79.1
  BOTTOM w0.089: U1.U5 30.13,64.75 v1(30.19,64.75)
CLK_REQ6_CR#: length 54
  TOP w0.102: v1(28.54,80.88) v2(28.54,80.1) 28.54,79.23 30.28,77.49 30.28,76.37 30.13,76.22 30.13,75.19 29.09,74.16 v1(28.87,74.16)
  IN1 w0.102: v1(5.4,82.44) 4.64,81.68 4.64,79.1 4.41,78.87 4.41,75.95 5.92,74.44 6.88,74.44 7.43,74.99 10.05,74.99 10.52,75.46 11.08,75.46 11.96,76.33 14.97,76.33 16.12,77.47 17.98,77.47 21.26,80.76 23.8,80.76 24.52,81.48 27.94,81.48 v1(28.54,80.88)
  BOTTOM w0.089: U1.T2 28.98,67.15 28.77,67.36 28.77,68.08 28.48,68.37 28.48,68.86 28.65,69.03
  BOTTOM w0.102: CON10.47 4.99,81.24 5.4,81.65 v1(5.4,82.44) ; v1(28.87,74.16) 28.54,74.16 R81.2 27.92,73.54 27.92,72.07 R86.1 28.65,71.34 28.65,69.03
CLK_SEL: length 8.7
  TOP w0.102: U6.10 161.69,27.08 160.71,28.07 160.71,28.69 160.5,28.91 R133.1 160.94,29.62 160.94,30.88 161.27,31.21 161.27,31.67 161.41,31.81 R134.2 161.39,32.26 161.39,33.11 v2(162,33.72)
CLK_XDP_N_R: length 11.3
  TOP w0.102: 73.97,13.92 73.61,13.92 72.21,15.32 71.71,15.32 71.12,15.92 70.85,15.92 GR11.2 ; 73.97,13.92 v2(73.97,14.2) ; 73.97,13.92 76.8,13.92 77.23,13.49 77.23,11.72 77.28,11.68 XDP1.42
CLK_XDP_P_R: length 11.2
  TOP w0.102: v2(75.54,13.4) 75.54,13.68 ; 75.54,13.68 76.7,13.68 76.99,13.39 76.99,11.85 76.78,11.64 XDP1.40 ; 75.54,13.68 73.51,13.68 72.11,15.08 71.61,15.08 71.02,15.68 70.87,15.68 70.79,15.6 70.79,15.35 GR8.2
CLKREQ#_MSATA: length 255.1
  TOP w0.102: v2(108.71,20.31) v1(108.71,21.21)
  IN2 w0.102: v1(153.65,25.98) 154.05,26.38 154.05,33.56 157.23,36.74 157.23,38.88 152.63,43.48 152.63,62.47 147.42,67.67 147.42,76.02 143.68,79.77 143.68,80.66 142.51,81.84 127.1,81.84 126.83,81.56 120.7,81.56 120.09,80.95 115.94,80.95 115.69,81.2 109.78,81.2 v1(108.66,82.32)
  IN3 w0.102: v1(108.66,82.32) 107.26,83.72 100.27,83.72 99.77,83.22 98.78,83.22 98.15,82.59 93.54,82.59 92.45,83.68 90.12,83.68 89.92,83.89 84.99,83.89 84.23,84.65 68.44,84.65 68.37,84.58 62.47,84.58 62.26,84.36 61.74,84.36 60.91,83.53 59.62,83.53 58.4,82.31 57.18,82.31 56.27,81.41 55.43,81.41 54.74,80.73 50.4,80.73 49.15,79.47 47.23,79.47 46.71,78.96 43.7,78.96 42.43,80.22 41.2,80.22 40.31,79.34 38.18,79.34 37.92,79.6 37.48,79.6 37.29,79.4 36.59,79.4 35.7,78.52 35.38,78.52 34.74,77.87 33.82,77.87 33.54,78.15 30,78.15 29.34,77.49 29.34,76.4 28.96,76.01 28.45,76.01 v1(28.25,75.81) ; v1(108.71,21.21) 110.12,22.62 122.87,22.62 123.55,23.31 136.4,23.31 139.57,20.13 145.31,20.13 151.16,25.98 v1(153.65,25.98)
  BOTTOM w0.089: U1.N1 27.73,67.86
  BOTTOM w0.102: CONSATA.52 104.93,19.58 105.23,19.88 105.23,22.93 105.41,23.11 106.83,23.11 108.71,21.22 v1(108.71,21.21) ; 27.73,67.86 27.73,68.76 27.43,69.06 27.43,70.02 27.74,70.32 27.74,71.04 R87.1 27.71,71.93 27.71,72.81 27.24,73.27 R82.1 27.24,73.63 27.67,74.05 27.67,75.08 28.02,75.43 28.02,75.58 v1(28.25,75.81)
CM1: length 3
  TOP w0.102: T36.1 26.6,82.57 26.6,83.91 26.22,84.29 U13.14
CM2: length 3
  TOP w0.102: v1(38.59,82.4) 37.81,82.4 37.55,82.66 U14.14
  BOTTOM w0.102: v1(38.59,82.4) 39.04,81.95 T38.1
CONFIG_0: length 120.5
  IN2 w0.102: v1(45.34,78.53) 45.36,78.51 49.47,78.51 50.5,77.47 57.94,77.47 58.74,76.67 64.33,76.67 64.59,76.93 88.54,76.93 89.33,77.72 v1(89.33,78.58)
  BOTTOM w0.089: U1.AP1 39.59,67.94 39.59,68.9 39.61,68.93
  BOTTOM w0.102: CONSATA.21 96.73,27.33 99.01,29.61 99.01,34.18 97.59,35.6 96.04,35.6 95.17,36.48 PQ8.1 95.17,39.8 94.31,40.66 93.63,40.66 v2(93.17,41.11) 92.84,41.44 92.84,66.79 93,66.96 93,70.36 92.77,70.6 92.77,71.12 91.16,72.73 91.16,73.62 89.33,75.45 v1(89.33,78.58) ; v1(45.34,78.53) 45.34,77.86 45.15,77.67 44.5,77.67 43.04,76.22 42.81,76.22 42.14,75.55 42.14,74.45 SR79.2 41.97,73.78 42.27,73.78 42.55,73.5 42.55,71.67 42.76,71.45 SR78.1 42.6,71.07 42.6,70.53 42.04,69.97 40.17,69.97 39.61,69.4 39.61,68.93
CONFIG_1: length 239
  TOP w0.102: v2(101.17,37.08) v1(102.01,37.08) ; SR80.2 41.22,75.08 v1(41.08,74.93)
  IN2 w0.102: v1(148.19,44.88) 151.46,48.15 151.46,61.94 146.13,67.27 146.13,74.29 145.15,75.26 142.39,75.26 141.93,75.73 139.98,75.73 139.32,75.07 122.25,75.07 121.05,73.87 114.62,73.87 113.61,74.87 113.61,75.71 112.89,76.43 108.57,76.43 108.14,76 101.51,76 101.34,76.17 96.41,76.17 95.45,77.13 90.38,77.13 88.89,75.65 83.1,75.65 82.37,74.92 78.36,74.92 77.47,75.81 67.13,75.81 66.52,75.21 64.43,75.21 64.17,74.95 58.88,74.95 57.94,75.89 54,75.89 53.62,75.51 45.71,75.51 45.21,76.01 43.33,76.01 42.26,74.93 v1(41.08,74.93)
  IN3 w0.102: v1(148.19,44.88) 144.12,40.81 143.41,40.81 142.72,40.12 142.72,39.41 140.16,36.85 136.22,36.85 134.77,35.4 117.55,35.4 117.17,35.02 113.87,35.02 111.66,32.81 107.72,32.81 103.46,37.08 v1(102.01,37.08)
  BOTTOM w0.089: 37.9,68.44 37.9,67.6 37.94,67.57 37.94,66.94 37.89,66.89 37.89,66.24 37.51,65.86 U1.AL4
  BOTTOM w0.102: 37.9,68.44 37.9,69.2 38.82,70.12 39.44,70.12 39.86,70.54 40.55,70.54 41.07,71.06 41.07,71.8 40.95,71.92 40.95,74.8 v1(41.08,74.93) ; v1(102.01,37.08) 101.24,37.85 PQ7.1 100.67,37.85 99.74,36.91 99.74,36.49 99.21,35.97 99.21,31.84 100.78,30.28 100.78,21.04 99.67,19.93 99.67,18.52 97.68,16.52 97.68,15.52 97.48,15.33 CONSATA.69
CONFIG_2: length 154.9
  TOP w0.089: 41.31,70.68 41.31,70.18 42.27,69.23 42.27,67.73 40.1,65.57 v1(40.1,65.37)
  TOP w0.102: v1(82.91,85.08) 82.59,85.4 82.59,87.26 82.34,87.5 72.01,87.5 71.57,87.06 66.96,87.06 66.13,86.22 v2(64.06,86.22) 63.69,86.59 58.8,86.59 55.79,83.58 52.62,83.58 51.92,82.88 49.67,82.88 49.46,82.67 49.46,78.74 49.98,78.22 49.98,76.78 49.11,75.91 48.19,75.91 47.35,75.07 46.97,75.07 45.57,73.67 43.1,73.67 42.43,73 42.43,72.38 SR81.2 41.68,71.84 41.31,71.48 41.31,70.68 ; v1(89.49,16.63) 88.85,17.26 88.85,21.18 89.28,21.61 89.28,22.7 88.98,23 88.98,28.39 89.28,28.69 89.28,36.97 89.77,37.46 89.77,37.99 93.04,41.27 93.04,67.15 91.26,68.93 v1(91.26,69.13)
  IN1 w0.102: v1(89.49,16.63) 89.49,17.1 89.86,17.47 92.94,17.47 93.87,18.39 94.91,18.39 96.95,16.35 v1(98.1,16.35)
  BOTTOM w0.089: v1(40.1,65.37) 40.1,65.34 40.48,64.96 U1.AT5
  BOTTOM w0.102: v1(82.91,85.08) 83.22,84.76 83.22,82.95 81.95,81.68 81.95,77.79 84.03,75.72 86,75.72 89.03,72.69 89.03,72.26 90.62,70.68 90.62,69.78 v1(91.26,69.13) ; CONSATA.75 97.48,13.83 98.1,14.44 v1(98.1,16.35)
CONFIG_3: length 118.3
  TOP w0.102: v2(90.32,74.41) 89.77,74.41 v1(89.18,75)
  IN2 w0.089: 44.63,70.93 44.63,68.75 43.41,67.53 38.46,67.53 36.63,69.35 36.63,69.59 36.63,69.59 36.63,69.61 36.25,69.99 v1(36.25,70.04)
  IN2 w0.102: v1(89.18,75) 88.5,74.31 77.4,74.31 76.53,75.18 67.51,75.18 66.94,74.6 64.8,74.6 63.68,73.47 58.14,73.47 57.72,73.89 53.1,73.89 52.64,73.44 46.29,73.44 44.63,71.77 44.63,70.93
  BOTTOM w0.089: v1(36.25,70.04) 36.86,70.65 ; 36.68,69.16 36.64,69.12 36.64,68.64 36.26,68.26 36.26,67.44 36.32,67.38 36.32,66.16 U1.AH4
  BOTTOM w0.102: v1(89.18,75) 89.49,75 90.96,73.53 90.96,72.64 92.56,71.04 92.56,70.52 92.8,70.28 92.8,67.37 92.64,67.2 92.64,40.78 94.51,38.9 94.51,36.77 95.91,35.37 97.36,35.37 98.73,34 98.73,32.76 98.3,32.33 CONSATA.1 ; SR82.2 37.09,70.88 36.86,70.65 ; v1(36.25,70.04) 36.68,69.61 36.68,69.16
CPU_PWR_DEBUG: length 110.3
  TOP w0.089: v1(23.59,31.45) 23.17,31.03 23.17,30.6 22.79,30.22 v2(22.07,30.22)
  IN2 w0.089: v1(23.59,31.45) 23.19,31.85 22.51,31.85 22.25,31.59 22.25,30.19 21.9,29.84 21.9,26.46 22.91,25.45 22.91,23.15 23.23,22.83
  IN2 w0.102: v1(98.81,11.17) 96.37,8.73 93.19,8.73 87.61,3.14 64.54,3.14 62.87,4.81 59.6,4.81 58.49,3.69 50.67,3.69 49.47,4.88 48.06,4.88 44.83,8.11 44.83,10 40.67,14.16 27.66,14.16 23.85,17.97 23.85,22.21 23.23,22.83
  BOTTOM w0.089: v1(23.59,31.45) 24.33,31.45 U1.H59
  BOTTOM w0.102: GU2.4 98.41,10.29 98.5,10.38 GR25.2 100.1,10.38 GR27.1 99.33,11.17 v1(98.81,11.17)
CPU_VARY_BL: length 3.8
  TOP w0.102: U6.48 165.29,18.5 165.93,17.85 GR39.2 v2(167.03,16.63)
CPU_VR_EN: length 38.4
  TOP w0.089: 26.48,23.08 26.48,23.7 HR28.1
  TOP w0.102: 26.48,23.08 HR31.1 25.25,20.67 25.25,17.54 v2(24.41,16.71) 23.7,15.99 14.6,15.99 14.15,16.45 12.58,16.45 12.01,17.01 11.67,17.01 11.42,16.77 11.42,14.1 10.85,13.53 7.39,13.53 5.75,15.17 5.75,20.88 v1(6.35,21.48)
  BOTTOM w0.102: PR102.1 6.67,21.8 v1(6.35,21.48)
CPU_VR_EN_R: length 11.5
  TOP w0.089: v1(24.26,27.68) 24.31,27.68 26.48,25.51 HR28.2 25.94,24.6 25.81,24.47 25.81,23.08
  TOP w0.102: 25.81,23.08 25.81,21.94 v2(25.38,21.51)
  BOTTOM w0.089: U1.F60 24.28,30.83 24.28,28.95 24.26,28.92 v1(24.26,27.68)
CPU_VR_READY: length 296.5
  IN1 w0.102: v1(100.18,88.35) 101.06,87.47 105.93,87.47 106.18,87.72 108.39,87.72 108.87,87.25 108.87,87.23 109.26,86.83 111.57,86.83 111.93,87.2 114.94,87.2 114.95,87.19 116.44,87.19 117.16,87.91 118.64,87.91 119.29,87.25 120.05,87.25 v1(120.63,86.68)
  IN3 w0.102: v1(138.74,19.8) 135.61,22.93 129.11,22.93 128.04,21.86 126.85,21.86 124.26,19.27 116.66,19.27 109.44,12.04 104.71,12.04 102.24,9.57 99.65,9.57 98.38,8.3 97.4,8.3 94.73,5.63 93.78,5.63 91.96,3.81 78.65,3.81 77.85,4.61 59.02,4.61 58.25,5.38 54.36,5.38 v1(53.93,5.81) ; v1(156.42,35.27) 156.42,35.33 161.77,40.68 161.77,58.83 164.34,61.4 164.34,65.57 165.15,66.38 165.15,68.6 163.78,69.97 163.78,72.96 164.31,73.49 164.31,78.4 163.68,79.04 162.74,79.04 161.65,77.94 159.09,77.94 158.15,78.88 153.55,78.88 152.27,77.61 150.83,77.61 150.11,76.89 140.72,76.89 140.27,77.33 135.03,77.33 134.65,76.95 123.06,76.95 v1(122.05,77.97)
  BOTTOM w0.102: v1(120.63,86.68) 121.08,86.22 123.47,86.22 125.2,87.95 126.87,87.95 127.36,87.47 127.36,82.86 122.46,77.97 v1(122.05,77.97) ; U10.34 100.98,88.99 100.86,88.87 100.7,88.87 v1(100.18,88.35) ; v1(156.42,35.27) 147.5,26.35 147.5,22.51 144.79,19.8 v1(138.74,19.8) ; R60477.1 24.79,9.85 27.59,12.64 28.93,12.64 v2(29.64,13.35) 30.96,14.67 40.26,14.67 44.52,10.41 44.52,5.68 45.16,5.03 49.67,5.03 50.1,4.6 52.72,4.6 v1(53.93,5.81)
CPU_VR_READY_R: length 37.6
  TOP w0.102: HR31.2 26.48,18.8 25.99,18.3 25.99,16.51 v2(23.95,14.48) 22.94,13.47 22.94,9.86 v1(22.93,9.85)
  IN2 w0.102: v1(16.74,21.38) 18.81,19.3 18.81,14.38 22.94,10.25 22.94,9.86 v1(22.93,9.85)
  BOTTOM w0.102: HR29.1 15.42,28.02 HC8.1 16.04,28.26 16.77,28.26 16.99,28.03 16.99,27.45 17.81,26.64 17.81,24.63 17.6,24.43 17.6,22.24 v1(16.74,21.38) ; R60477.2 v1(22.93,9.85)
CPU_VR_READY_RR: length 7.6
  BOTTOM w0.089: 17.3,28.39 v2(17.48,28.22) 19.2,29.94 19.2,30.4 20.21,31.4 20.99,31.4 21.1,31.51 21.21,31.51 21.6,31.9 U1.C59
  BOTTOM w0.102: HR29.2 16.6,28.54 17.15,28.54 17.3,28.39
CPU_VRON: length 207.9
  TOP w0.102: v1(119.99,86.67) 119.6,86.28 119.6,85.07 119.86,84.81 119.86,83.8 119.46,83.39 v1(119.46,82.19)
  TOP w0.254: v1(7.08,23.64) 7.73,22.98 v2(8.35,22.98)
  IN1 w0.102: v1(109.29,82.32) 109.85,81.77 119.04,81.77 v1(119.46,82.19)
  IN2 w0.102: v1(7.08,23.64) 7.75,24.31 7.75,25.62 8.21,26.08 10.26,26.08 11.25,27.07 11.25,32.95 10.62,33.59 10.62,46.06 11.2,46.65 11.2,46.73 11.19,46.74 11.19,48.5 9.56,50.13 9.07,50.13 7.16,52.03 7.16,62.14 6.92,62.39 6.92,76.44 7.48,77 7.48,77.98 9.45,79.95 9.81,79.95 11.58,81.73 11.58,82.77 13.72,84.9 15.36,84.9 16.41,85.95 16.99,85.95 18.44,87.4 21.64,87.4 23.88,89.64 42.4,89.64 43.44,88.6 51.6,88.6 52.63,89.64 64.8,89.64 65.33,89.11 67.45,89.11 68.59,90.25 119.78,90.25 120.74,89.29 120.74,87.76 119.99,87.01 v1(119.99,86.67)
  BOTTOM w0.102: PR217.1 7.36,23.92 v1(7.08,23.64) ; v1(109.29,82.32) 109.29,81.75 109.99,81.06 112.66,81.06 113.19,80.53 U10.84
CURRENT_MODIFY: length 79.1
  TOP w0.102: v1(137.52,49.96) 137.8,49.68 137.8,48.73 140.18,46.35 v2(140.44,46.35) 142.75,46.35 v1(143.31,45.79) ; v1(130.25,67.62) 130.25,68.9 129.77,69.38 129.77,82.03 130.06,82.33 130.06,82.95 129.51,83.5 129.51,85.53 128.12,86.92 127.17,86.92 126.21,87.88 123.27,87.88 123.12,87.72 v1(123.12,86.81)
  IN3 w0.102: v1(143.31,45.79) 141.91,47.19 141.91,53.88 140.81,54.97 140.37,54.97 136.76,58.59 134.22,58.59 134.11,58.69 131.41,58.69 130.38,59.72 130.38,65.31 130.82,65.75 130.82,67.05 v1(130.25,67.62)
  BOTTOM w0.102: v1(137.52,49.96) 136.84,49.96 PC69.1 137.04,50.46 138.08,50.46 138.15,50.39 PU3.7 ; v1(123.12,86.81) 122.75,87.18 119.66,87.18 119.01,87.83 118.31,87.83 118.05,87.56 117.31,87.56 C72.1 116.88,86.62 116.61,86.35 116.49,86.35 115.47,85.33 U10.72
DC_IN_ID_ADAP: length 95.4
  TOP w0.102: v1(158.65,38.27) 158.65,37.94 158.15,37.44 D18.3 157.43,36.87 157.27,36.71 R343.2 156.41,36.29 v2(156.14,36.01)
  IN3 w0.102: v1(103.89,72.05) 105.22,70.72 109.83,70.72 110.2,71.09 143.89,71.09 146.03,68.95 153.15,68.95 153.68,68.42 155.93,68.42 162.35,62.01 162.35,59.69 161.56,58.91 161.56,41.21 158.65,38.3 v1(158.65,38.27)
  BOTTOM w0.102: U10.118 104.58,73.28 103.89,72.59 v1(103.89,72.05) 103.68,71.84 R202.2
DC_IN_ID_ADAP_B: length 10
  TOP w0.089: v1(16.84,53.23) 16.84,53.78 v2(16.97,53.9)
  BOTTOM w0.102: U15.3 16.37,54.08 16.84,53.61 v1(16.84,53.23) 16.84,51.07 16.18,50.41 15.67,50.41 15.5,50.24 L8.1
DC_IN_ID_ADAP_Q: length 262.9
  TOP w0.102: v2(164.92,35.88) 164.7,35.65 163.04,35.65 162.84,35.86 161.63,35.86 R344.1 160.73,36.29 160.61,36.16 C156.1 160.16,36.82 160.31,36.97 Q36.3 160.31,38.13 161.09,38.9 v1(162.56,38.9)
  IN2 w0.089: 16.77,55.95 v1(16.94,55.77)
  IN2 w0.102: v1(162.56,38.9) 163.25,39.59 163.25,42.26 164.59,43.6 164.59,53.05 163.77,53.87 163.77,56.98 166.52,59.73 166.52,67.9 171.13,72.51 171.13,74.11 168.66,76.58 168.66,78.48 165.17,81.97 147.97,81.97 144.95,84.99 141.8,84.99 140.5,86.29 134.04,86.29 133.56,85.81 130.93,85.81 130,84.88 120.15,84.88 117.73,84.88 116.87,85.74 116.35,85.74 116.34,85.74 115.49,85.74 115.49,85.74 115.44,85.74 114.48,86.71 114.48,87.9 113.17,89.21 74.45,89.21 73.34,88.09 64.97,88.09 64.05,87.17 59.62,87.17 59.29,86.83 57.33,86.83 56.62,87.54 54.84,87.54 54.03,88.36 52.79,88.36 52.02,87.59 40.35,87.59 39.32,88.62 24.3,88.62 21.17,85.49 17.96,85.49 17.41,84.94 16.83,84.94 15.63,83.74 14.1,83.74 12.7,82.34 12.7,81.35 9.78,78.43 9.5,78.43 7.32,76.25 7.32,62.88 14.25,55.95 16.77,55.95
  BOTTOM w0.102: L8.2 16.84,50.48 17.26,50.91 17.26,54.26 16.79,54.73 16.79,55.62 v1(16.94,55.77)
DC_IN_ID_ADAP_R: length 6
  TOP w0.102: R343.1 158.1,36.81 159.36,38.07 Q36.2 v2(159.36,41.75)
DC_IN_ID_POGO: length 224.7
  TOP w0.102: R201.2 109.39,81.36 109.15,81.6 108.33,81.6 108.02,81.92 v1(108.02,82.32)
  IN2 w0.102: v1(153.62,26.74) 153.62,34.82 154.86,36.06 156.22,36.06 157.02,36.87 157.02,38.52 152.43,43.12 152.43,62.38 147.22,67.59 147.22,75.94 142.86,80.29 140.98,80.29 139.64,81.63 127.19,81.63 126.92,81.36 120.79,81.36 120.18,80.75 115.86,80.75 115.61,81 109.6,81 108.69,81.9 108.44,81.9 v1(108.02,82.32)
  IN3 w0.102: v1(153.62,26.74) 151.39,26.74 145.11,20.46 139.68,20.46 136.6,23.54 123.42,23.54 122.71,22.83 108.89,22.83 107.85,21.78 107.85,18.75 103.42,14.32 100.89,14.32 v1(98.93,12.36)
  BOTTOM w0.102: v2(54.92,9.75) 55.24,10.07 D15.3 56.42,11.36 55.97,11.81 55.97,12.85 56.26,13.14 58.08,13.14 58.63,12.58 R339.2 59.06,12.22 65.12,12.22 67.08,14.18 71.64,14.18 72.34,13.48 74.06,13.48 75.23,12.31 86.23,12.31 87,13.07 88.74,13.07 89.99,11.83 98.18,11.83 98.42,12.07 98.64,12.07 v1(98.93,12.36) ; v1(108.02,82.32) 108.02,81.76 108.93,80.85 111.93,80.85 112.65,80.13 U10.85
DC_IN_ID_POGO_B: length 15.4
  BOTTOM w0.381: v2(63.5,5.05) 63.07,5.48 L7.1 63.27,6.17 63.96,6.86 D16.1 64.8,6.86 67.9,9.96 67.9,11.02 68.46,11.58 68.46,12.08 68.78,12.41 70.68,12.41 71.15,11.95 71.15,11.22 71.5,10.86 J1.3
DC_IN_ID_POGO_Q: length 2.2
  TOP w0.102: v2(61.75,10.1) 62.38,9.47 v1(62.38,8.96)
  BOTTOM w0.508: 62.31,7.51 62.31,7.51 L7.2
DC_IN_ID_POGO_R: length 5.5
  BOTTOM w0.102: Q34.2 60.26,11.57 60.04,11.79 R339.1 59.05,11.38 57.73,11.38 v2(56.47,12.64)
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: U1.B3 21.04,66.67 U1.A3
DC_TEST_A61_B61: length 7
  BOTTOM w0.089: U1.B61 20.9,30.49 20.83,30.42 U1.A61 20.37,30.42 19.92,29.96 19.92,27.6 20.43,27.09 20.43,26.62 19.84,26.03 19.84,25.37
  BOTTOM w0.102: 19.84,25.37 v2(19.84,24.9)
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.089: U1.AW2 42.79,67.14 42.9,67.26 U1.AY2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.089: U1.AY3 42.93,66.54 42.87,66.48 U1.AW3
DC_TEST_AY61_AW61: length 5.9
  BOTTOM w0.089: U1.AW61 43.06,30.48 U1.AY61 44.21,29.33 45.34,29.33 45.95,29.94 v2(47.63,29.94)
DC_TEST_AY62_AW62: length 4.3
  BOTTOM w0.089: v2(46.2,28.41) 44.47,28.41 U1.AY62 43.06,29.83 U1.AW62
DC_TEST_B62_B63: length 3.8
  BOTTOM w0.089: v2(21.12,26.12) 21.12,28.38 21.11,28.39 U1.B63 21.24,29.31 U1.B62
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.089: U1.C1 21.77,67.68 U1.C2
DDPB_AUXN: length 233.1
  TOP w0.102: v1(167.01,47.08) 166.83,47.26 166.48,47.26 S1C1.1 ; v1(168.86,88.1) 169.93,87.04 174.62,87.04 175.13,86.52 175.13,83.15 174.88,82.9 174.88,80.09 173.88,79.09 168.73,79.09 ; v1(166.68,77.89) 167.87,79.09 168.73,79.09 ; 168.73,79.09 v2(168.73,79.38)
  IN3 w0.114: v1(18.39,65.93) 18.03,65.93 17.93,66.03 17.93,68.48 19.61,70.15 19.61,74.6 20.6,75.59 20.6,78.97 23.65,82.02 23.65,82.57 24.82,83.74 30.91,83.74 31.36,84.18 32.12,84.18 32.62,84.68 37.92,84.68 38.25,85 43.18,85 43.73,84.45 46.36,84.45 47.04,85.13 54.71,85.13 55.52,85.95 56.87,85.95 61.33,90.41 142.48,90.41 143.31,89.58 151.52,89.58 152.16,90.21 167.44,90.21 169.04,88.61 169.04,88.29 168.99,88.24 168.99,88.23 v1(168.86,88.1) ; v1(167.01,47.08) 166.88,47.21 165.39,47.21 164.34,48.26 164.34,52.72 163.7,53.36 163.7,57.82 166.57,60.68 166.57,73.13 167.18,73.75 167.18,76.5 166.85,76.83 166.85,77.72 v1(166.68,77.89)
  BOTTOM w0.089: U1.C5 21.35,65.03 21.29,64.97 20.7,64.97 20.65,64.91 19.94,64.91 19.23,65.63 18.57,65.63 18.39,65.8 v1(18.39,65.93)
DDPB_AUXN_C: length 12.9
  TOP w0.102: S1R4.2 163.03,47.21 163.65,47.21 v1(163.91,46.96) 164.16,47.21 164.6,47.21 S1C1.2
  BOTTOM w0.102: CONWIFI.20 172.31,46.6 172.19,46.73 168.21,46.73 167.93,46.45 165.91,46.45 165.09,47.26 164.21,47.26 v1(163.91,46.96)
DDPB_AUXP: length 233.2
  TOP w0.102: v1(169.5,88.1) 169.39,88 169.39,87.86 170.01,87.24 174.7,87.24 175.34,86.61 175.34,83.07 175.08,82.81 175.08,80 173.97,78.88 170.61,78.88 ; v2(170.61,78.59) 170.61,78.88 ; 170.61,78.88 167.95,78.88 167.31,78.24 v1(167.31,77.89) ; S1C2.1 166.41,47.46 166.75,47.46 v1(167.01,47.72)
  IN3 w0.114: v1(167.31,77.89) 167.08,77.67 167.08,76.93 167.41,76.6 167.41,73.65 166.8,73.04 166.8,60.59 163.93,57.73 163.93,53.45 164.57,52.82 164.57,48.35 165.48,47.44 166.73,47.44 v1(167.01,47.72) ; v1(169.5,88.1) 169.27,88.33 169.27,88.71 167.53,90.44 152.06,90.44 151.43,89.81 143.41,89.81 142.57,90.64 61.24,90.64 56.78,86.18 55.43,86.18 54.61,85.36 46.94,85.36 46.26,84.68 43.82,84.68 43.28,85.23 38.15,85.23 37.83,84.9 32.52,84.9 32.03,84.41 31.26,84.41 30.82,83.96 24.72,83.96 23.42,82.66 23.42,82.11 20.37,79.06 20.37,75.68 19.38,74.69 19.38,70.25 17.71,68.57 17.71,65.93 v1(18.37,65.27)
  BOTTOM w0.089: U1.B5 21.04,64.79 20.78,64.79 20.73,64.74 19.87,64.74 19.16,65.45 18.54,65.45 v1(18.37,65.27)
DDPB_AUXP_C: length 13
  TOP w0.102: S1C2.2 164.56,47.41 164.21,47.41 v1(163.91,47.72) 163.6,47.41 163.07,47.41 S1R5.1
  BOTTOM w0.102: v1(163.91,47.72) 164.16,47.46 165.18,47.46 165.99,46.65 167.84,46.65 168.12,46.93 172.14,46.93 172.32,47.1 CONWIFI.22
DDPB_CTRLDATA: length 24.7
  TOP w0.102: v2(8.84,74.82) 9.76,74.82 R60359.2 10.75,74.81 10.75,74.36 v1(10.97,74.13)
  IN2 w0.102: v1(18.53,61.69) 18.02,61.18 17.2,61.18 16.96,61.42 16.96,62.81 11.18,68.6 11.18,72.76 11.58,73.17 11.58,73.52 v1(10.97,74.13)
  BOTTOM w0.089: v1(18.53,61.69) 18.53,61.95 18.85,62.27 20.04,62.27 20.32,61.99 20.75,61.99 20.96,61.79 21.28,61.79 21.71,62.22 U1.C9
DDPB_HPD: length 234.1
  TOP w0.102: v1(12.74,73.69) 12.52,73.91 R60364.1
  IN1 w0.102: v1(170.71,72.85) 171.16,72.41 175.31,72.41 180.72,67 180.72,51.43 v1(179.3,50)
  IN2 w0.102: v1(170.71,72.85) 170.71,74.24 168.45,76.5 168.45,78.35 165.04,81.77 147.74,81.77 144.72,84.79 141.71,84.79 140.42,86.09 134.12,86.09 133.63,85.59 131.01,85.59 130.1,84.68 118.98,84.68 118.98,84.68 118.64,84.68 118.64,84.68 116.1,84.68 114.28,86.5 114.28,87.25 113.66,87.86 111.96,87.86 111.69,88.14 111.69,88.79 111.47,89.01 74.54,89.01 73.42,87.89 65.06,87.89 64.14,86.97 59.73,86.97 59.39,86.63 57.24,86.63 56.54,87.34 54.76,87.34 53.94,88.16 52.87,88.16 52.1,87.38 40.27,87.38 39.23,88.42 24.39,88.42 21.25,85.29 18.04,85.29 17.49,84.73 16.92,84.73 16.41,84.23 16.41,80.92 14.99,79.49 14.99,77.46 13.95,76.42 12.98,76.42 12.74,76.18 v1(12.74,73.69) 12.74,73.36 13.16,72.94 13.16,71.65 12.55,71.04 12.55,70.15 14.23,68.47 14.23,66.37 17.13,63.47 v1(17.73,63.47)
  BOTTOM w0.089: U1.C8 21.1,63.27 20.81,63.57 20.1,63.57 19.96,63.7 19,63.7
  BOTTOM w0.102: v1(179.3,50) 179.95,49.35 CONWIFI.31 ; 19,63.7 18.34,63.7 18.12,63.47 v1(17.73,63.47) ; v2(171.55,74.41) 170.71,73.58 v1(170.71,72.85)
DDPC_CTRLDATA: length 23.7
  TOP w0.102: v1(10.92,73.5) 11.25,73.5 11.43,73.68 v2(11.43,74.77) 11.43,75.25 11.3,75.38 R60362.2
  IN2 w0.102: v1(19.18,61.69) 18.47,60.98 17.14,60.98 16.76,61.35 16.76,62.73 10.97,68.51 10.97,73.45 v1(10.92,73.5)
  BOTTOM w0.089: U1.D11 21.72,61.95 21.38,61.61 20.79,61.61 20.58,61.82 20.22,61.82 19.94,62.09 19.58,62.09 v1(19.18,61.69)
DDR3_DRAMRST#: length 98.5
  TOP w0.102: v1(70.69,19.64) 70.72,19.66 70.72,21.74 70.14,22.32 68.94,22.32 68,23.26 68,24.91 68.23,25.14 69.38,25.14 D3C7.1 70.69,25.55 v1(71.02,25.21) ; U4.T2 84.89,54.35 85.47,54.93 85.47,55.67 85.78,55.98 86.26,55.98 86.5,56.22 86.5,56.57 86.67,56.74 v1(89.08,56.74) ; U3.T2 84.47,34.54 85.17,35.24 v1(88.8,35.24) 88.8,36.12 v2(88.79,36.14) ; v1(87.89,64.69) 86.26,64.69 85.8,65.14 85.8,65.42 85.34,65.89 U5.T2 ; U2.T2 84.28,23.01 v1(84.53,23.26) 84.7,23.26 C1.1 86.89,22.84 R38.2 88.06,22.84 R39.2
  IN3 w0.102: v1(84.53,23.26) 83.92,23.87 83.42,23.87 81.64,22.09 80.14,22.09 79.96,21.91 79.96,20.95 79.76,20.74 77.17,20.74 76.06,19.64 v1(70.69,19.64)
  BOTTOM w0.102: v1(71.02,25.21) 70.68,25.55 DIMM1.30 ; v1(84.53,23.26) 86.31,25.04 86.31,25.99 87.55,27.23 88.18,27.23 88.8,27.86 v1(88.8,35.24) 88.8,37.52 88.71,37.61 88.71,39.4 88.98,39.67 88.98,40.91 89.89,41.83 89.89,44.77 89.41,45.26 89.41,53.66 88.7,54.37 88.7,56.35 v1(89.08,56.74) 89.61,57.27 89.61,60.62 88.34,61.89 88.34,64.23 v1(87.89,64.69)
DDR_PG_CTRL: length 75.3
  TOP w0.102: v1(114.37,66.76) 114.75,66.39 PR162.1 ; v1(63.44,72.62) 63.35,72.53 63.35,72.18 62.99,71.82 62.99,70.31 HR10.2 62.71,69.75 62.46,69.5 62.18,69.5 HR11.2 62.23,68.25 62.47,68.25 62.71,68.01 62.71,67.25 HR13.1 63.47,66.95 64.47,66.95 65.01,66.41 HQ2.1 65.26,66.97 64.74,67.49 HU1.4 ; v2(90.88,65.83) v1(90.88,66.67)
  IN1 w0.102: v1(90.88,66.67) 90.88,68.17 90.1,68.95 89.23,68.95 88.93,69.26 88.93,71.59 87.17,73.35 84.45,73.35 84.17,73.63 67.87,73.63 66.14,71.9 65.61,71.9 65.33,72.18 64.62,72.18 64.18,72.62 v1(63.44,72.62)
  IN2 w0.102: v1(94.34,64.53) 93.02,64.53 v1(90.88,66.67)
  IN3 w0.102: v1(114.37,66.76) 113.35,67.78 108.63,67.78 107.94,67.09 105.65,67.09 103.35,64.79 101.5,64.79 100.6,63.89 94.98,63.89 v1(94.34,64.53)
DDR_PG_CTRL_S: length 154
  TOP w0.102: v1(90.07,55.59) 90.48,55.19 91.85,55.19 92.08,55.41 92.08,66.36 90.55,67.89 90.55,70.08 89.9,70.73 89.9,71.39 89.02,72.27 87.76,72.27 86.12,73.91 80.78,73.91 80.05,73.18 77.17,73.18 76.42,73.93 68.35,73.93 67.26,72.84 HR12.1 66.75,71.73 66.7,71.78 66.05,71.78 65.39,71.12 HU1.2
  IN2 w0.089: 43.24,22.96 42.35,23.84 40.08,23.84 v1(38.79,22.55)
  IN2 w0.102: v1(90.07,55.59) 90.07,55.31 89.64,54.88 89.64,48.77 90.73,47.68 90.73,23.08 88.37,20.72 88.37,19.29 85.48,16.4 78.31,16.4 76.65,14.74 67.3,14.74 64.45,17.58 57.65,17.58 57.27,17.2 48.87,17.2 47.96,18.11 47.96,19.06 45.69,21.33 43.69,21.33 43.28,21.73 43.28,22.91 43.24,22.96
  BOTTOM w0.089: U1.AV61 41.19,30.13 41.05,30.13 40.86,29.94 40.86,28.95 41.07,28.74 41.16,28.74 41.65,28.25 41.65,28.14 42.44,27.36 42.44,26.44 41.37,25.37 41.28,25.37
  BOTTOM w0.102: 41.28,25.37 40.77,24.86 40.11,24.86 v2(38.81,23.56) 38.79,23.54 v1(38.79,22.55)
DE_11: length 3.8
  TOP w0.178: U13.3 21.57,85.29 21.3,85.02 21.3,84.29 20.96,83.95 v2(20.96,83.61) 20.96,83.06 20.92,83.02 R328.1
DE_12: length 5.3
  TOP w0.254: U13.16 26.42,85.29 26.98,84.73 26.98,84.55 27.39,84.13 R330.1 27.5,83.92 27.79,83.63 29.01,83.63 R325.2 29.26,84.27 29.31,84.32 v2(29.31,84.85)
DE_21: length 2.4
  TOP w0.254: R336.1 32.48,83.66 U14.3
DE_22: length 5.6
  TOP w0.254: U14.16 38.47,83.66 R338.1 39.24,83.35 39.91,83.35 R333.2 40.51,83.63 40.51,83 40.98,82.53 v2(40.98,82.53)
DET_RIO#: length 174.2
  TOP w0.102: v2(171.77,86.02) C182.1 R145.2 171.77,82.55 172.7,81.63 v1(174.22,81.63)
  IN1 w0.102: v1(133.21,77.84) 133.8,78.43 135.13,78.43 135.41,78.15 149.52,78.15 151.38,80 155.02,80 156.87,81.86 163.55,81.86 165.62,83.93 168.36,83.93 170.36,81.93 173.92,81.93 v1(174.22,81.63)
  IN2 w0.089: v1(27.89,69.89) 28.17,69.89 29.21,70.93
  IN2 w0.102: 29.21,70.93 33.86,75.58 33.86,76.21 34.37,76.72 42.75,76.72 43.63,77.6 48.15,77.6 48.8,76.95 49.3,76.95 50,76.26 53.46,76.26 53.72,76.52 58.32,76.52 58.57,76.27 64.5,76.27 64.75,76.52 88.71,76.52 90.12,77.93 95.68,77.93 96.83,76.78 99.05,76.78 99.89,77.61 102.44,77.61 102.76,77.28 108.97,77.28 109.24,77.01 112.89,77.01 114.02,75.88 114.02,75.04 114.27,74.79 116.1,74.79 117.77,76.47 131.84,76.47 v1(133.21,77.84)
  BOTTOM w0.089: U1.P2 28.48,67.38 28.2,67.67 28.2,68.16 28.3,68.27 28.3,69.79 28.2,69.89 v1(27.89,69.89)
  BOTTOM w0.102: v1(174.22,81.63) 175.72,81.63 176.35,82.26 176.35,83.12 176.56,83.32 176.56,83.56 176.96,83.96 177.6,83.96 177.75,84.12 CON11.3
DET_SPK_L#: length 58.8
  TOP w0.089: 27.93,70.68 27.95,70.65 28.2,70.65 29.83,69.02 29.83,66.37 v1(29.61,66.15)
  TOP w0.102: R148.1 7.49,81.74 7.49,83.33 v1(6.66,84.17) ; 27.93,70.68 27.81,70.79 27.81,74.47 27.69,74.6 27.69,75.91 26.67,76.93 v2(26.67,79.67) 26.9,79.9 26.9,80.6 v1(27.08,80.78)
  IN1 w0.102: v1(27.08,80.78) 26.61,81.25 24.58,81.25 23.89,80.56 21.35,80.56 18.02,77.23 16.16,77.23 15.06,76.13 12.04,76.13 11.17,75.25 10.6,75.25 10.13,74.78 7.56,74.78 6.96,74.19 5.85,74.19 4.21,75.83 4.21,78.96 4.43,79.18 4.43,82.88 5.72,84.17 v1(6.66,84.17)
  BOTTOM w0.089: v1(29.61,66.15) 29.26,66.5 U1.T3
  BOTTOM w0.102: CON10.13 6.97,83.24 6.66,83.56 v1(6.66,84.17)
DIFFCLK_BIASREF: length 20.9
  IN2 w0.102: v1(16.52,45.56) 16.08,46 16.08,50.6 18.7,53.22 19.12,53.22 v1(19.56,52.77)
  BOTTOM w0.089: U1.C26 21.92,52.53 21.61,52.84 21.33,52.84 21.1,52.61 19.72,52.61 v1(19.56,52.77)
  BOTTOM w0.102: CKR2.1 12.83,41.01 12.79,41.05 v2(12.79,41.6) 12.79,43.57 13.72,44.49 15.91,44.49 16.52,45.1 v1(16.52,45.56)
DIMM0_VREF_DQ: length 47.6
  TOP w0.089: v2(41.03,37.48) 40.72,37.48 40.67,37.53 v1(40.35,37.53)
  TOP w0.508: v1(72.72,17.72) C42.1 74.65,17.75 R42.1
  IN2 w0.508: v1(72.72,17.72) 71.67,16.67 68.93,16.67 66.75,18.85 66.75,19.44 65.78,20.41 59.49,20.41 49.18,30.73 49.18,31.67 46.99,33.85 46.99,35.09 45.87,36.21 42.57,36.21 41.16,37.62 40.48,37.62 40.38,37.53 v1(40.35,37.53)
  BOTTOM w0.254: v1(40.35,37.53) 40.35,37.44 40.03,37.12 U1.AR51
DIMM1_VREF_DQ: length 39.2
  TOP w0.508: v1(47.4,22.47) 46.2,21.28 46.2,19.85 45.34,18.99 45.34,16.31 46.44,15.21 49.05,15.21 v2(49.66,14.6) 51.47,14.6 R56.1 53.93,15.78 C45.2 55.39,16.7 ; 55.39,16.7 56.07,16.02 R66.2 ; 55.39,16.7 R60.2
  IN2 w0.508: v1(47.4,22.47) 47.4,24.66 41.76,30.29 41.76,33.57 39.72,35.61 v1(39.72,36.62)
  BOTTOM w0.254: v1(39.72,36.62) 39.72,36.65 39.38,36.99 U1.AP51
DIMM1_VREF_DQ_R: length 6.6
  TOP w0.508: R66.1 57.99,16.91 C1194.1 58.03,16.88 59.32,16.88 C1195.1 59.71,16.5 v1(60.86,16.5) 60.86,16.07 v2(60.56,15.77)
  BOTTOM w0.356: v1(60.86,16.5) 60.51,16.85 DIMM1.1
DIMM_VREF_CA: length 33
  TOP w0.508: v2(50.93,18.64) 50.78,18.49 R43.2 ; v2(50.93,18.64) 52.14,18.64 R57.1 52.25,19.35 52.71,19.81 C46.2 53.93,19.81 54.05,19.69 R61.2 55.68,19.69 R59.2 ; v2(50.93,18.64) 50.59,18.98 C43.1 50.88,19.8 51.46,20.39 51.46,21.99 v1(51.06,22.39)
  IN2 w0.254: 40.84,37.03 40.13,37.03 39.63,37.53 v1(39.05,37.53)
  IN2 w0.508: v1(51.06,22.39) 51.06,22.65 43.23,30.47 43.23,34.64 40.84,37.03
  BOTTOM w0.254: U1.AP49 39.38,38.05 39.05,37.72 v1(39.05,37.53)
DIMM_VREF_CA_R: length 124.9
  TOP w0.508: v1(62.03,16.55) 62.03,17.26 61.37,17.92 60.28,17.92 59.95,18.25 v2(59.44,18.25) 59.12,18.57 C1192.1 C1193.1 56.35,18.57 56.12,18.8 R59.1
  IN1 w0.508: v1(75.03,20.54) 83.08,20.54 84.56,22.01 84.98,22.01 87.47,24.5 87.47,26.16 90.73,29.42 90.73,35.12 90.1,35.76 90.1,41.29 89.38,42 89.38,51.99 90.86,53.46 90.86,58.79 90.1,59.55 90.1,63.47 89.18,64.38 89.18,65.42 87.83,66.77 87.83,69.4 84.83,72.41 84.07,72.41 83.87,72.6 73.79,72.6 72.75,71.56 72.19,71.56 71.53,72.22 68.9,72.22 67.98,71.3 67.98,61.65 67.69,61.36 67.69,58.69 69.1,57.29 v1(69.1,57.05)
  BOTTOM w0.356: DIMM1.126 68.8,56.75 v1(69.1,57.05)
  BOTTOM w0.508: v1(75.03,20.54) 74.35,20.54 73.23,19.42 71.4,19.42 70.79,18.81 70.79,16.98 70.41,16.6 62.08,16.6 v1(62.03,16.55)
DISABLE_ME#: length 28.4
  IN2 w0.089: v1(38.6,66.81) 38.42,66.81 38.13,66.51 38.13,66.11 38.45,65.78 40.29,65.78 40.87,66.36 49.51,66.36
  IN2 w0.102: v1(54.71,65.37) 51.95,65.37 50.95,66.36 49.51,66.36
  BOTTOM w0.089: U1.AM3 38.28,66.5 38.59,66.81 v1(38.6,66.81)
  BOTTOM w0.102: v1(54.71,65.37) 55.26,65.92 SR2.1 56.09,66.46 56.09,66.51 R89.2 57.61,65.64 57.61,65.13 R88.2 57.1,63.92 57.3,63.72 57.3,62.32 57.1,62.12 v2(56.49,62.12)
DMIC_CLK: length 156.7
  TOP w0.102: v2(144.35,89.07) v1(144.35,90.39)
  IN1 w0.102: v1(144.35,90.39) 143.92,89.96 143.38,89.96 142.89,90.45 53.35,90.45 52.27,89.37 43.51,89.37 42.44,90.45 23.99,90.45 22.4,88.87 20.26,88.87 19.22,89.91 12.81,89.91 10.88,87.99 8.11,87.99 7.55,87.42 v1(6.35,87.42)
  BOTTOM w0.102: v1(144.35,90.39) 144.35,89.68 144.8,89.23 144.8,85.67 145.25,85.22 145.58,85.22 146.13,84.67 VU2.2 146.38,84.12 146.38,82.74 146.75,82.38 R250.1 ; v1(6.35,87.42) 6.35,88.36 6.74,88.74 CON10.2
DMIC_CLK_OB: length 6.6
  BOTTOM w0.102: VU2.4 147.08,81.18 147.5,80.76 148.09,80.76 R249.1 148.24,80.17 148.24,78.63 147.96,78.35 146.46,78.35 146.2,78.6 v2(146.2,79.09)
DMIC_CLK_Q: length 17.7
  BOTTOM w0.102: v2(148.74,78.73) 148.74,79.42 149.18,79.85 149.18,80.57 R249.2 148.99,81.82 148.99,82.79 R250.2 148.56,83.5 148.56,83.51 C103.1 148.66,83.86 150.42,83.86 150.7,84.14 150.7,85.21 151.03,85.54 155.16,85.54 156.31,84.39 CON6.8
DMIC_DATA: length 153.5
  TOP w0.102: v1(144.35,87.6) v2(144.35,86.89)
  IN1 w0.102: v1(147.91,87.6) 147.49,87.18 144.77,87.18 v1(144.35,87.6) ; v1(5.88,87.86) 6.51,87.86 6.69,87.67 7.51,87.67 8.03,88.19 10.7,88.19 12.63,90.11 19.3,90.11 20.35,89.07 22.32,89.07 23.9,90.65 42.52,90.65 43.6,89.58 52.17,89.58 53.25,90.65 143.45,90.65 v1(143.71,90.39)
  BOTTOM w0.102: CON10.1 7.08,89.49 5.88,88.29 v1(5.88,87.86) ; v1(144.35,87.6) 144.35,88.74 143.71,89.37 v1(143.71,90.39) ; R248.2 R247.1 148.17,87.6 v1(147.91,87.6)
DMIC_DATA_OB: length 5.9
  TOP w0.102: v2(146.56,86.96) 146.56,87.27 v1(146.2,87.62)
  BOTTOM w0.102: R248.1 148.13,89.14 148.13,88.75 147.45,88.08 146.66,88.08 v1(146.2,87.62) 145.42,88.4 VU1.4
DMIC_DATA_Q: length 17.4
  BOTTOM w0.102: v2(159.99,84.48) 159.99,84.49 159.9,84.58 159.9,85.36 159.27,85.99 CON6.6 152.76,85.99 151.61,87.15 R247.2 C102.1 147.92,85.75 147.92,85.5 147.63,85.21 146.58,85.21 146.37,85.42 VU1.2
DP_COMP: length 2.9
  TOP w0.089: v2(22,56.86) 22.1,56.86 v1(22.71,56.25)
  TOP w0.254: HR16.2 22.05,55.58 v1(22.71,56.25)
  BOTTOM w0.254: U1.D20 22.3,56.66 v1(22.71,56.25)
DP_DDI1_C_TX0: length 6.7
  TOP w0.102: v1(169.11,52.42) 168.86,52.16 168.67,52.16 S1C6.2
  BOTTOM w0.102: v1(169.11,52.42) 169.39,52.14 170.42,52.14 170.84,51.71 170.84,50.98 171.86,49.96 172.09,49.96 172.24,50.1 CONWIFI.34
DP_DDI1_C_TX0#: length 6.7
  TOP w0.102: v1(169.11,51.78) 168.94,51.96 168.71,51.96 S1C5.2
  BOTTOM w0.102: CONWIFI.32 172.24,49.6 172.09,49.75 171.78,49.75 170.64,50.89 170.64,51.63 170.33,51.93 169.27,51.93 v1(169.11,51.78)
DP_DDI1_C_TX1: length 6
  TOP w0.102: S1C4.2 168.71,49.83 168.84,49.83 v1(169.11,50.11)
  BOTTOM w0.102: v1(169.11,50.11) 169.34,49.88 169.62,49.88 171.05,48.46 172.09,48.46 172.24,48.6 CONWIFI.28
DP_DDI1_C_TX1#: length 5.9
  TOP w0.102: S1C3.2 168.59,49.62 168.96,49.62 v1(169.11,49.47)
  BOTTOM w0.102: v1(169.11,49.47) 169.32,49.67 169.54,49.67 170.96,48.25 172.09,48.25 172.24,48.1 CONWIFI.26
DP_DDI1_C_TX2: length 19.8
  TOP w0.102: 170.87,56.56 171.45,56.56 v1(171.78,56.89) ; 170.87,56.56 168.63,56.56 S1C10.1 ; 170.87,56.56 v2(170.87,56.85)
  IN3 w0.114: v1(178.92,48.53) 178.72,48.33 176.43,48.33 173.74,51.02 173.74,55.95 172.8,56.89 v1(171.78,56.89)
  BOTTOM w0.102: v1(178.92,48.53) 179.22,48.23 179.81,48.23 179.94,48.35 CONWIFI.27
DP_DDI1_C_TX2#: length 19.9
  TOP w0.102: S1C9.1 168.63,56.35 169.29,56.35 ; 169.29,56.35 171.65,56.35 v1(171.78,56.23) ; 169.29,56.35 v2(169.29,56.06)
  IN3 w0.114: v1(178.92,47.9) 178.72,48.1 176.34,48.1 173.51,50.93 173.51,55.85 172.7,56.66 172.21,56.66 v1(171.78,56.23)
  BOTTOM w0.102: CONWIFI.25 179.96,47.85 179.79,48.02 179.05,48.02 v1(178.92,47.9)
DP_DDI1_C_TX3: length 18.1
  TOP w0.102: v1(169.44,54.83) 168.96,54.35 168.61,54.35 S1C8.1
  IN3 w0.114: v1(179,46.93) 178.84,46.78 178.66,46.78 178,47.44 175.41,47.44 172.65,50.2 172.65,53.08 171.86,53.87 170.84,53.87 170.12,54.58 169.7,54.58 v1(169.44,54.83)
  BOTTOM w0.102: CONWIFI.21 179.96,46.85 179.83,46.73 179.2,46.73 v1(179,46.93)
DP_DDI1_C_TX3#: length 18.1
  TOP w0.102: v1(169.44,54.02) 169.32,54.14 168.63,54.14 S1C7.1
  IN3 w0.114: v1(179,46.3) 178.97,46.3 178.72,46.55 178.56,46.55 177.9,47.21 175.31,47.21 172.42,50.11 172.42,52.98 171.76,53.64 170.74,53.64 170.03,54.35 169.78,54.35 v1(169.44,54.02)
  BOTTOM w0.102: v1(179,46.3) 179.22,46.52 179.81,46.52 179.99,46.35 CONWIFI.19
DP_DDI1_TX0: length 186
  TOP w0.102: 165.66,51.53 164.54,51.53 162.82,49.8 161.49,49.8 v1(161.01,50.28) ; 165.66,51.53 166.42,51.53 166.56,51.67 166.56,52.02 166.37,52.21 166.37,52.47 166.52,52.61 S1C6.1 ; 165.66,51.53 v2(165.66,51.82)
  IN1 w0.127: v1(161.01,50.28) 161.47,49.83 162.2,49.83 162.51,49.52 162.51,43.45 158.52,39.46 157.23,39.46 156.24,38.47 154.64,38.47 152.38,36.21 145.06,36.21 135.33,26.48 125.35,26.48 124.72,25.85 96.5,25.85 95.54,26.81 92.58,26.81 82.12,16.35 76.23,16.35 75.74,15.87 71.9,15.87 71.17,15.13 65.76,15.13 64.54,16.35 62.96,16.35 62.4,15.79 54.87,15.79 51.74,18.91 47.86,18.91 45.98,20.79 44.17,20.79 42.81,22.16 42.81,22.78 42.23,23.36 38.46,23.36 38.13,23.69 27.34,23.69 25.03,26 23.95,26 23.45,26.51 23.45,28.09 22.89,28.64 22.36,28.64 20.85,30.15 20.85,33.32 20.06,34.12 v1(19.61,34.12)
  BOTTOM w0.089: U1.C55 21.58,34.2 21.58,34.19 21.54,34.13 21.43,34.03 21.37,33.98 21.23,33.95 21.09,33.95 20.91,34.01 20.79,34.01 20.68,33.97 20.64,33.96 20.64,33.96 20.57,33.95 20.5,33.93 20.44,33.92 20.15,33.92 19.95,34.12 v1(19.61,34.12)
DP_DDI1_TX0#: length 186.1
  TOP w0.102: 162.38,49.6 162.9,49.6 164.63,51.33 166.51,51.33 166.65,51.47 S1C5.1 ; 162.38,49.6 v1(161.01,49.6) ; 162.38,49.6 v2(162.38,49.31)
  IN1 w0.127: v1(18.98,34.12) 19.42,34.56 19.94,34.56 21.08,33.42 21.08,30.24 22.46,28.87 22.99,28.87 23.67,28.19 23.67,26.6 24.05,26.23 25.12,26.23 27.43,23.92 38.23,23.92 38.56,23.59 42.32,23.59 43.04,22.88 43.04,22.25 44.27,21.02 46.08,21.02 47.96,19.14 51.84,19.14 54.96,16.02 62.31,16.02 62.87,16.58 64.64,16.58 65.86,15.36 71.07,15.36 71.81,16.1 75.65,16.1 76.13,16.58 82.02,16.58 92.49,27.04 95.63,27.04 96.6,26.08 124.62,26.08 125.26,26.71 135.24,26.71 144.97,36.44 152.28,36.44 154.54,38.7 156.14,38.7 157.13,39.69 158.43,39.69 162.28,43.55 162.28,49.42 162.1,49.6 v1(161.01,49.6)
  BOTTOM w0.089: 19,34.15 19.08,34.22 19.08,34.23 19.38,34.54 19.79,34.54 20.01,34.31 20.01,34.31 20.21,34.11 20.36,34.11 20.37,34.1 20.43,34.1 20.53,34.12 20.6,34.14 20.63,34.15 20.81,34.2 20.91,34.2 21.12,34.13 21.21,34.13 21.29,34.15 21.32,34.17 21.4,34.24 21.42,34.27 21.5,34.45 21.5,34.47 21.6,34.63 21.83,34.82 U1.C54
  BOTTOM w0.102: 19,34.15 v1(18.98,34.12)
