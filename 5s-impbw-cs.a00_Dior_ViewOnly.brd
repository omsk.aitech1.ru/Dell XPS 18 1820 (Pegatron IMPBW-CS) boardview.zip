# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB_CLK_S: length 254.5
  TOP w0.102: v1(166.93,80.99) 165.63,82.29 164.17,82.29 164.13,82.26 U16.4 ; v1(101.68,18.81) 101.88,18.61 102.39,18.61 R281.2 ; v1(99.85,32.68) 98.68,33.85 95.35,33.85 94.95,34.26 90.31,34.26 v1(90.11,34.05) ; R309.2 172.35,59.38 v2(172.2,59.22) 171.58,59.22 v1(169.88,60.93) ; XDP1.53 80.28,5.52 82.12,7.36 85.5,7.36 86.64,8.5 87.73,8.5 v1(88.34,7.89)
  IN1 w0.127: v1(169.88,60.93) 169.69,60.74 168.16,60.74 166.59,59.17 165.44,59.17 161.49,55.23 161.49,54.52 148.3,41.32 143.06,41.32 140.96,39.21 137.73,39.21 133.88,35.36 133.88,31.81 132.02,29.94 108.04,29.94 107,30.98 105.17,30.98 101.74,34.41 100.23,34.41 99.42,33.6 99.42,33.11 v1(99.85,32.68)
  IN3 w0.102: v1(166.93,80.99) 167.35,81.41 167.79,81.41 168.04,81.17 168.04,80.94 169.84,79.13 169.84,71.98 170.17,71.65 170.17,66.02 169.66,65.51 169.66,61.14 v1(169.88,60.93) ; v1(101.68,18.81) 100.66,17.8 100.23,17.8 97.69,15.26 96.87,15.26 96.27,14.65 96.27,12.06 93.39,9.19 91.29,9.19 90.9,8.81 89.26,8.81 v1(88.34,7.89)
  BOTTOM w0.102: SR73.1 68.83,86.68 SQ1.1 68.07,87.56 67.94,87.42 SR71.1 66.49,86.5 65.43,86.5 65.05,86.12 65.05,82.98 66.12,81.91 66.12,79.96 66.52,79.55 DIMM1.202 68.55,79.55 68.9,79.2 69.68,79.2 75.5,73.38 86,73.38 87.24,72.14 87.24,67.26 90.18,64.32 90.18,60.81 90.77,60.22 90.77,54.29 90.55,54.07 90.55,45.73 91.06,45.22 91.06,41.37 90.04,40.35 90.04,35.64 90.53,35.16 90.53,34.47 v1(90.11,34.05) ; v1(99.85,32.68) 99.85,32.1 101.93,30.01 101.93,19.07 v1(101.68,18.81)
SMB_DAT_S: length 259
  TOP w0.102: v1(90.11,34.76) 90.36,34.51 95.05,34.51 95.46,34.1 99.06,34.1 v1(99.85,33.32) ; v1(88.98,7.89) 88.11,8.75 86.49,8.75 85.35,7.61 82.01,7.61 79.78,5.37 XDP1.51 ; v1(167.62,81) 165.94,82.68 U16.6 ; R308.2 172.86,58.54 172.67,58.73 171.62,58.73 170.61,59.73 v2(170.36,59.73) 170.36,59.81 v1(169.88,60.29) ; R280.2 102.25,18.36 101.86,18.36 v1(101.68,18.18)
  IN1 w0.127: v1(99.85,33.32) 99.85,33.63 100.35,34.13 101.63,34.13 105.06,30.7 106.89,30.7 107.93,29.66 132.13,29.66 134.16,31.69 134.16,35.25 137.85,38.93 141.07,38.93 143.18,41.04 148.41,41.04 161.77,54.4 161.77,55.11 165.56,58.89 166.7,58.89 168.27,60.46 169.7,60.46 v1(169.88,60.29)
  IN3 w0.102: v1(169.88,60.29) 169.41,60.76 169.41,65.62 169.91,66.12 169.91,71.54 169.58,71.87 169.58,79.03 v1(167.62,81) ; v1(88.98,7.89) 89.64,8.55 91.01,8.55 91.39,8.93 93.5,8.93 96.55,11.98 96.55,14.57 96.98,15 97.79,15 100.33,17.54 100.77,17.54 101.4,18.18 v1(101.68,18.18)
  BOTTOM w0.102: v1(90.11,34.76) 89.82,35.06 89.82,40.48 90.81,41.47 90.81,45.12 90.3,45.62 90.3,54.1 90.52,54.32 90.52,60.18 89.98,60.72 89.98,64.22 86.99,67.21 86.99,72.04 85.89,73.13 75.4,73.13 69.58,78.95 DIMM1.200 66.3,78.95 65.86,79.39 65.86,81.8 64.72,82.95 64.72,88.16 65,88.43 67.01,88.43 67.16,88.59 67.16,90.44 67.34,90.62 68.37,90.62 SR74.1 SR72.1 70.42,89.62 70.73,89.31 SQ1.4 ; v1(99.85,33.32) 100.27,32.9 100.27,32.04 102.19,30.12 102.19,18.69 v1(101.68,18.18)
SMB_DATA_M_MINI0: length 5.1
  TOP w0.102: R308.1 v1(174.72,58.54) 174.98,58.27 v2(174.98,57.85)
  BOTTOM w0.102: CONWIFI.58 174.02,56.1 174.32,56.41 174.32,58.15 v1(174.72,58.54)
SMB_DATA_M_MSATA0: length 5.7
  TOP w0.102: R280.1 103.47,17.32 103.85,16.94 v2(104.53,16.94) 105.02,16.94 105.51,17.44 v1(105.51,18.05)
  BOTTOM w0.102: CONSATA.56 104.98,18.58 v1(105.51,18.05)
SML0_CLK: length 7.2
  BOTTOM w0.089: U1.AN1 38.97,68.93
  BOTTOM w0.102: 38.97,68.93 38.77,69.13 38.77,69.5 39.01,69.74 39.59,69.74 40.02,70.16 41.93,70.16 42.32,70.54 42.32,71.11 R406.1
SML0_CLK_EC: length 119.1
  TOP w0.102: Q40.3 135.47,14.81 135.87,15.21 135.87,16.47 136.22,16.82 136.22,18.66 v2(136.68,19.12) 136.91,19.35 136.91,27.81 137.74,28.64 137.74,31.35 140,33.6 140.48,33.6 144.43,37.55 144.43,45.48 140.62,49.29 139.24,49.29 136.96,51.58 136.96,52.16 v1(137.8,53)
  IN1 w0.127: v1(137.8,53) 137.8,53.07 139.89,55.16 141.61,55.16 146.48,60.04 146.48,64.05 144.72,65.82 144.72,68.7 143.27,70.15 135.38,70.15 134.23,68.99 132.86,68.99 131.27,70.58 125.77,70.58 124.18,68.99 122.27,68.99 120.57,70.69 117.93,70.69 116.93,71.7 113.99,71.7 113.29,72.4 113.29,72.64 112.41,73.53 111.67,73.53 109.25,75.95 107.46,75.95 v1(106.76,76.65)
  BOTTOM w0.102: R195.2 108.08,71.99 108.08,72.53 107.78,72.82 U10.110 107.78,74.92 107.8,74.94 107.8,75.61 v1(106.76,76.65) ; PR88.2 137.8,53.12 v1(137.8,53)
SML0_CLK_EC_Q: length 9.8
  TOP w0.102: Q40.4 135.9,14.81 135.23,14.14 135.23,13.23 135.57,12.88 136.03,12.88 136.17,12.74 136.17,12.07 R352.2 134.83,10.72 v2(134.83,9.98) 134.83,9.28 v1(134,8.46)
  BOTTOM w0.102: CON9.4 v1(134,8.46)
SML0_DAT: length 5
  BOTTOM w0.089: 37.06,68.9 37.06,68.52 36.73,68.18 U1.AK1
  BOTTOM w0.102: R407.1 37.09,69.82 37.09,68.93 37.06,68.9
SML0_DATA_EC: length 120.1
  TOP w0.102: v1(137.41,51.73) 138.05,51.1 138.05,50.87 139.37,49.55 140.77,49.55 144.68,45.64 144.68,37.44 140.64,33.4 140.16,33.4 138,31.24 138,28.41 137.24,27.65 137.24,17.62 v2(136.98,17.37) 136.54,16.93 136.54,16.78 136.54,16.78 Q40.6
  IN1 w0.127: v1(106.13,76.65) 106.56,77.08 108.51,77.08 111.79,73.81 113.23,73.81 113.57,73.46 113.57,72.51 114.11,71.98 117.05,71.98 118.05,70.97 121.46,70.97 121.9,70.54 121.9,69.76 122.39,69.27 124.07,69.27 125.65,70.86 131.38,70.86 132.97,69.27 134.11,69.27 135.27,70.43 143.45,70.43 145,68.88 145,65.93 146.76,64.17 146.76,59.92 141.72,54.88 140.01,54.88 138.25,53.13 138.25,52.57 v1(137.41,51.73)
  BOTTOM w0.102: v1(137.41,51.73) 137.41,52.14 137.16,52.4 136.43,52.4 PR89.2 ; v1(106.13,76.65) 106.13,76.24 106.71,75.66 107.28,75.66 107.55,75.39 107.55,75.04 107.38,74.88 U10.111 107.38,72.86 107.8,72.45 R196.2
SML0_DATA_EC_Q: length 10.7
  TOP w0.102: Q40.1 133.76,16.11 133.68,16.04 133.68,14.67 134.22,14.14 134.22,12.09 R351.2 134.7,11.19 133.12,9.61 v2(133.12,9.34) 133.12,8.95 133.22,8.84 v1(133.22,8.46)
  BOTTOM w0.102: v1(133.22,8.46) 133.22,8.48 133.5,8.75 CON9.5
SML0ALERT#: length 10
  BOTTOM w0.089: U1.AL2 37.45,67.15 37.01,67.59 37.01,68.17 37.29,68.45 37.29,68.93
  BOTTOM w0.102: R405.2 40.44,73.86 40.37,73.78 39.86,73.78 39.61,73.53 39.61,73.16 39.84,72.93 40.03,72.93 40.29,72.67 40.29,72.25 39.57,71.54 39.57,71.34 39.08,70.84 38.65,70.84 37.29,69.49 37.29,68.93
SML1_CLK: length 54.6
  TOP w0.102: v1(49.54,71.51) 49.89,71.51 49.98,71.59 RN3.2 50.34,72.25 51.74,73.65 51.74,74.65 54.22,77.13 54.22,79.86 v2(54.71,80.36) 55.53,81.17 56.72,81.17 59.27,83.72 60.12,83.72 60.39,83.99 64.08,83.99 64.69,83.38 67.64,83.38 68.53,84.27 69.11,84.27 v1(70.26,85.41)
  IN3 w0.102: v1(49.54,71.51) 49.23,71.19 49.23,71.06 47.62,69.45 47.03,69.45 44.73,67.15 41.27,67.15 40.78,67.64 40.21,68.21 40.06,68.36 40.06,68.72 v1(40.48,69.15)
  BOTTOM w0.089: U1.AU3 41.16,66.7 40.84,67.02 40.84,68.21 40.87,68.23 40.87,68.76 40.7,68.93
  BOTTOM w0.102: 40.7,68.93 v1(40.48,69.15) ; SQ2.6 72.74,88.86 72.99,89.11 SR75.1 72.52,90.11 72.34,89.93 72.34,89.8 71.99,89.45 71.99,85.16 71.68,84.85 70.82,84.85 v1(70.26,85.41)
SML1_CLK_EC: length 196.3
  TOP w0.102: v1(93.63,68.44) 93.63,69.03 89.42,73.23 88.16,73.23 86.04,75.35 83.47,75.35 83.06,75.76 83.06,75.86 83.06,75.86 83.06,76.07 82.67,76.46 80.76,76.46 80.76,76.46 80.33,76.46 79.23,77.56 73.67,77.56 R226.2 ; U6.51 167.29,20.72 R135.2 168.65,20.36 170.97,20.36 v1(171.07,20.26) v2(172.19,20.26) ; U12.8 75.19,79.59 R226.2 ; v1(71.55,85.41) 71.99,84.98 71.99,78.65 72.12,78.51 72.73,78.51 R226.2
  IN3 w0.102: v1(164.28,67.76) 164.06,67.76 163.95,67.64 160.5,67.64 160.19,67.96 157.89,67.96 156.76,69.09 153.73,69.09 153.23,69.59 146.11,69.59 144.1,71.59 109.91,71.59 109.54,71.23 106.47,71.23 v1(105.41,72.28) 105.41,72.67 104.56,73.52 101.29,73.52 99,71.23 96.64,71.23 94.44,69.03 93.91,69.03 93.63,68.75 v1(93.63,68.44) ; v1(163.78,49.12) 163.39,48.72 163.39,46.1 163.76,45.72 167.37,45.72 167.87,45.23 167.87,39.01 v1(168.1,38.78)
  BOTTOM w0.102: v1(71.55,85.41) 71.73,85.59 71.73,89.55 72.09,89.91 72.09,90.08 72.65,90.64 73.53,90.64 73.88,90.3 SR75.2 73.88,89.23 74.25,88.86 SQ2.1 ; v1(171.07,20.26) 170.64,20.69 170.64,23.31 172.52,25.19 172.52,34.37 172.09,34.8 172.09,39.08 171.68,39.49 168.81,39.49 v1(168.1,38.78) ; R197.2 105.32,72.19 v1(105.41,72.28) 105.41,72.62 105.78,72.99 U10.115 ; Q15.2 163.28,69.76 R259.1 R253.2 163.82,68.22 v1(164.28,67.76) 164,67.48 164,65.79 166.87,62.92 166.87,52.66 165.84,51.63 164.16,51.63 163.36,50.83 163.36,49.53 v1(163.78,49.12)
SML1_CLK_EC_Q: length 22.1
  BOTTOM w0.102: R259.2 164.66,69.92 164.23,70.35 Q15.3 164.23,74.13 R260.2 164.29,74.53 164.27,74.55 R256.2 163.82,75.06 v2(164.34,75.58) 164.19,75.73 162.08,75.73 161.22,76.59 161.22,77.67 159.17,79.72 157.46,79.72 157.13,80.05 157.13,81.24 156.92,81.45 156.92,83.13 157.39,83.59 CON6.9
SML1_DAT: length 56.2
  TOP w0.102: v1(69.56,85.4) 68.84,84.68 v2(67.72,84.68) 66.68,83.63 64.8,83.63 64.19,84.24 60.28,84.24 60.02,83.98 59.17,83.98 56.62,81.42 54.96,81.42 53.96,80.43 53.96,77.23 51.49,74.76 51.49,73.9 50.38,72.79 49.46,72.79 49.33,72.66 RN3.4 49.33,72.05 v1(48.45,71.18)
  IN3 w0.089: 41.6,69.72 40.49,69.72 38.49,67.72 36.51,67.72 v1(35.6,66.81)
  IN3 w0.102: 41.6,69.72 41.84,69.49 41.84,67.94 42.43,67.34 44.65,67.34 46.95,69.64 47.53,69.64 48.45,70.56 v1(48.45,71.18)
  BOTTOM w0.089: v1(35.6,66.81) 35.91,66.5 U1.AH3
  BOTTOM w0.102: v1(69.56,85.4) 70.49,84.47 71.71,84.47 72.37,85.14 73.06,85.14 73.55,85.63 SR76.1 73.55,87.3 73.8,87.56 SQ2.3
SML1_DATA_EC: length 191.2
  TOP w0.102: U6.52 167.95,21.12 R137.2 168.66,21.4 170.78,21.4 v1(171.07,21.11) 171.15,21.18 v2(171.15,21.89) ; v1(72.66,85.56) 72.66,83.67 72.34,83.35 72.34,80.74 72.9,80.18 72.9,79.49 R227.2 73.82,79.42 74.37,79.42 74.54,79.59 U12.7 74.54,81.55 74.75,81.75 75.39,81.75 75.64,81.5 75.64,79.17 75.64,79.17 75.64,78.96 76.7,77.91 79.25,77.91 80.44,76.72 80.65,76.72 80.65,76.72 82.56,76.72 82.77,76.72 83.31,76.18 83.31,75.97 83.67,75.61 86.15,75.61 88.27,73.49 89.53,73.49 94.26,68.76 v1(94.26,68.6)
  IN3 w0.102: v1(164.42,66.49) 163.54,67.37 160.42,67.37 160.08,67.71 157.78,67.71 156.65,68.84 153.62,68.84 153.13,69.33 146.01,69.33 144,71.34 110.1,71.34 109.73,70.97 105.5,70.97 104.7,71.77 v1(104.7,72.79) 104.22,73.26 101.39,73.26 99.11,70.98 96.75,70.98 94.37,68.6 v1(94.26,68.6) ; v1(163.78,49.75) 163.13,49.1 163.13,45.99 163.65,45.47 167.27,45.47 167.62,45.12 167.62,38.98 v1(167.41,38.78)
  BOTTOM w0.102: R198.2 104.5,72.59 v1(104.7,72.79) 105.03,72.79 105.38,73.14 U10.116 ; v1(171.07,21.11) 171.07,23.34 172.24,24.5 172.24,24.55 172.77,25.08 172.77,34.47 172.34,34.9 172.34,39.18 171.78,39.74 171.57,39.74 168.38,39.74 v1(167.41,38.78) ; Q16.2 166.51,69.94 166.74,69.71 R257.1 R251.2 166.74,67.37 165.61,66.24 164.67,66.24 v1(164.42,66.49) 164.42,65.73 167.12,63.03 167.12,52.55 165.94,51.38 164.27,51.38 163.78,50.89 v1(163.78,49.75) ; v1(72.66,85.56) SR76.2 72.66,86.99 72.54,87.1 SQ2.4
SML1_DATA_EC_Q: length 23
  BOTTOM w0.102: CON6.10 157.65,82.79 157.2,82.34 157.2,81.53 157.38,81.35 157.38,80.16 157.56,79.98 159.27,79.98 161.47,77.78 161.47,76.78 162.26,75.99 163.98,75.99 164.16,76.17 164.62,76.17 164.77,76.01 165.48,76.01 165.66,75.84 v2(166.08,75.84) 166.08,75.32 166.38,75.02 166.68,75.02 R255.2 167.58,74.57 167.59,74.58 R258.2 167.93,74.22 167.46,73.75 Q16.3 167.46,71.59 167.58,71.47 R257.2
SML1ALERT#: length 8.6
  TOP w0.089: v1(40.74,65.39) 40.74,65.81 42.13,67.2 v2(43.36,67.2) 43.89,67.2 44.55,67.86 44.91,67.86 45.29,68.24 45.29,68.72 44.7,69.31 RN8.3
  BOTTOM w0.089: U1.AU4 41.16,65.81 v1(40.74,65.39)
SML2_CLK_EC: length 28.3
  TOP w0.102: v2(114.58,69.87) 114.58,70.5 v1(114.68,70.6)
  IN1 w0.127: v1(128.56,68.32) 128.56,68.87 127.87,69.56 127.05,69.56 126.7,69.21 126.7,68.04 126.24,67.58 121.54,67.58 121.29,67.83 121.29,68.55 120.85,68.98 120.12,68.98 118.68,70.41 117.81,70.41 117.19,71.04 115.11,71.04 v1(114.68,70.6)
  BOTTOM w0.102: L9.2 128.84,68.6 v1(128.56,68.32) ; U10.94 115.46,76.53 115.82,76.17 115.82,74.74 115.52,74.44 115.52,71.98 R193.2 114.93,71.56 114.68,71.32 v1(114.68,70.6)
SML2_DATA_EC: length 27.2
  TOP w0.102: v2(115.72,68.52) 115.32,68.93 v1(115.32,70.6)
  IN1 w0.127: v1(115.32,70.6) 117.22,70.6 117.69,70.13 118.57,70.13 120,68.7 120.73,68.7 121.01,68.42 121.01,67.63 121.36,67.28 126.33,67.28 127.23,68.18 v1(127.23,69.13)
  BOTTOM w0.102: v1(127.23,69.13) 127.22,69.14 L10.2 ; U10.95 115.47,76.13 115.57,76.03 115.57,74.85 115.24,74.51 115.24,72.35 114.12,71.24 114.12,70.55 114.53,70.15 114.86,70.15 v1(115.32,70.6) 115.36,70.64 R194.2
SO: length 21.1
  TOP w0.102: v1(105.54,66.08) 105.13,66.08 103.53,64.48 v2(103.53,63.95)
  BOTTOM w0.102: v1(105.54,66.08) 105.78,66.33 U11.2 108.53,66.33 108.68,66.48 110.7,66.48 111.27,67.05 113.39,67.05 113.62,67.28 113.62,67.94 113.39,68.17 111.2,68.17 110.7,68.67 110.7,73.09 110.58,73.2 U10.103
SPI1_CLK: length 20.2
  TOP w0.102: v1(141.81,80.71) 141.71,80.81 v2(141.71,81.53) ; F3J1.4 v1(136.54,84.27)
  IN3 w0.102: v1(141.81,80.71) 139.76,82.76 139.76,82.88 139.98,83.09 140.15,83.09 141.72,81.52 141.87,81.52 142.08,81.73 142.08,81.88 140.35,83.61 138.36,83.61 138.14,83.39 138.14,82.78 138,82.64 137.72,82.64 137.57,82.8 137.57,83.24 v1(136.54,84.27)
  BOTTOM w0.102: F3R10.1 142.37,80.26 142.37,81.91 142.24,82.04 F3U1.6 141.75,80.77 v1(141.81,80.71)
SPI1_CS#0: length 24
  TOP w0.102: F3R14.2 137.43,81.44 138.04,82.05 F3J1.1 138.04,85.07 v1(138.27,85.31) 138.74,84.85 138.74,83.84 138.94,83.63 141.61,83.63 142.04,84.07 v2(142.7,84.07) 143.31,84.07 146.03,81.34 146.03,78.58 145.28,77.83 Q9202.3
  BOTTOM w0.102: v1(138.27,85.31) 138.27,85.94 139.21,86.88 F3U1.1
SPI1_HOLD#: length 5.3
  BOTTOM w0.102: F3U1.7 140.48,80.16 F3R3.2 139.91,79.56 139.91,79.39 F3R8.1 139.57,78.32 v2(138.74,77.49)
SPI1_MISO: length 26.4
  TOP w0.102: F3J1.7 135.04,84.11 v1(134.88,84.27)
  BOTTOM w0.102: v1(134.88,84.27) 134.32,84.83 134.32,85.51 135.13,86.33 135.13,90.16 135.26,90.29 135.64,90.29 135.76,90.16 135.76,87.04 135.89,86.91 138.71,86.91 138.84,87.04 138.84,87.44 138.71,87.57 v2(137.52,87.57) 136.78,87.57 136.65,87.7 136.65,88.05 136.78,88.18 138.41,88.18 138.53,88.31 138.53,89.76 138.22,90.06 F3R7.2 138.07,90.58 140.3,90.58 140.48,90.39 F3U1.2
SPI1_MOSI: length 23
  TOP w0.102: F3J1.5 136.04,84.1 v1(135.87,84.27)
  IN3 w0.102: v1(142.85,80.71) 144.1,80.71 144.22,80.59 144.22,80.13 144.4,79.95 144.81,79.95 144.93,80.08 144.93,81.5 144.81,81.63 143.23,81.63 141.02,83.84 138.58,83.84 138.46,83.96 138.46,84.55 138.25,84.75 136.35,84.75 v1(135.87,84.27)
  BOTTOM w0.102: v2(144.15,77.67) 144.43,77.94 144.43,79.35 F3R11.1 143.84,81.89 143.69,82.04 F3U1.5 143.02,80.88 v1(142.85,80.71)
SPI_CLK: length 140.4
  TOP w0.102: v1(141.15,80.71) 141.5,80.36 v2(141.5,79.67)
  IN3 w0.102: v1(31.54,69.94) 32.09,70.5 32.09,70.87 32.81,71.59 34.37,71.59 35.46,72.67 38.42,72.67 39.54,73.79 43.02,73.79 43.11,73.7 46.63,73.7 47.6,74.67 49.25,74.67 50.57,75.99 52.54,75.99 53.85,77.3 56.44,77.3 58.58,79.44 59.61,79.44 60.83,80.66 61.29,80.66 61.56,80.38 62.56,80.38 62.72,80.23 66.88,80.23 68.39,78.72 75.29,78.72 76.76,80.19 80.84,80.19 81.61,79.42 85.79,79.42 86.13,79.76 88.85,79.76 89.15,80.07 92.57,80.07 92.8,79.84 98.43,79.84 99.76,81.17 112.37,81.17 112.74,81.54 124.02,81.54 124.12,81.64 124.12,82.06 124.23,82.16 124.53,82.16 124.63,82.06 124.63,81.64 124.73,81.54 125.04,81.54 125.14,81.64 125.14,82.06 125.24,82.16 125.55,82.16 125.65,82.06 125.65,81.64 125.75,81.54 126.05,81.54 126.16,81.64 126.16,82.06 126.26,82.16 126.56,82.16 126.66,82.06 126.66,81.64 126.77,81.54 127.07,81.54 127.17,81.64 127.17,82.06 127.27,82.16 127.58,82.16 127.68,82.06 127.68,81.64 127.78,81.54 128.09,81.54 128.19,81.64 128.19,82.06 128.29,82.16 128.59,82.16 128.7,82.06 128.7,81.64 128.8,81.54 129.1,81.54 129.2,81.64 129.2,82.06 129.31,82.16 129.61,82.16 129.71,82.06 129.71,81.64 129.81,81.54 130.12,81.54 130.22,81.64 130.22,82.06 130.32,82.16 130.63,82.16 130.73,82.06 130.73,81.64 130.83,81.54 131.32,81.54 131.42,81.64 131.42,82.06 131.53,82.16 131.83,82.16 131.93,82.06 131.93,81.64 132.03,81.54 133.08,81.54 133.71,82.16 134.55,82.16 134.66,82.26 134.66,83.25 134.76,83.35 134.96,83.35 135.06,83.25 135.06,82.26 135.16,82.16 135.37,82.16 135.47,82.26 135.47,83.25 135.57,83.35 135.77,83.35 135.87,83.25 135.87,82.26 135.98,82.16 136.18,82.16 136.28,82.26 136.28,83.25 136.38,83.35 136.59,83.35 136.69,83.25 136.69,82.26 136.79,82.16 139.4,82.16 140.84,80.71 v1(141.15,80.71)
  BOTTOM w0.089: 32.14,68.93 32.14,68.68 32.69,68.12 32.69,67.33 32.56,67.2 32.56,66.88 U1.AA3
  BOTTOM w0.102: v1(31.54,69.94) 32.14,69.34 32.14,68.93 ; F3R10.2 141.91,79.82 141.48,79.82 141.15,80.15 v1(141.15,80.71)
SPI_CS#0: length 144.8
  TOP w0.102: Q9202.2 143.62,81.01 142.22,82.41 139.22,82.41 138.64,81.83 138.64,80.64 137.77,79.77 137.09,79.77 136.25,78.94 136.25,77.87 135.26,76.88 133.15,76.88 132.56,77.46 132.56,81.17 v2(132.06,81.68) 131.73,82.01 v1(131.73,83.08) 132.36,83.71 132.73,83.71 133.05,84.02 133.05,84.42 133.35,84.73 135.05,84.73 135.38,84.4 135.38,83.94 135.54,83.79 F3J1.6
  IN3 w0.089: v1(31.14,64.11) 30.59,64.66 30.59,65.6 30.51,65.68 30.51,68.71
  IN3 w0.102: v1(131.73,83.08) 131.27,83.53 130.51,83.53 130.05,83.08 113.31,83.08 112.09,81.85 99.48,81.85 98.15,80.52 94.68,80.52 94.07,81.13 85.95,81.13 85.71,81.37 83.44,81.37 82.95,80.88 76.48,80.88 75.01,79.4 68.67,79.4 67.16,80.92 63,80.92 62.85,81.07 61.85,81.07 61.57,81.35 60.55,81.35 59.33,80.13 58.29,80.13 56.15,77.99 53.57,77.99 53.06,77.47 51.54,77.47 50.82,76.75 48.71,76.75 47.66,75.7 41.22,75.7 40.79,75.28 37.34,75.28 36.7,74.64 35.46,74.64 34.31,73.49 34.31,73.34 33.27,72.3 32.47,72.3 31.53,71.37 31.37,71.37 30.51,70.5 30.51,68.71
  BOTTOM w0.089: v1(31.14,64.11) 31.38,63.87 U1.Y7
SPI_HOLD#: length 6.4
  BOTTOM w0.102: v2(109.48,63.49) 109.48,64.48 111.33,66.33 U11.7 113.41,66.33 113.64,66.1 R221.2
SPI_HOLD#_IO3: length 128.3
  IN3 w0.102: v1(35.21,70.96) 35.21,71.37 35.69,71.85 40.92,71.85 41.15,72.08 46.13,72.08 47.41,73.36 49.77,73.36 50.59,74.17 50.59,74.89 51,75.3 52.82,75.3 54.13,76.61 56.72,76.61 58.86,78.76 60.82,78.76 61.76,79.7 62.28,79.7 62.43,79.54 66.42,79.54 67.93,78.03 76.11,78.03 76.82,78.74 85.49,78.74 86,78.22 86.79,78.22 87.64,79.07 91.45,79.07 91.82,78.71 94.24,78.71 94.91,79.38 95.18,79.38 95.28,79.28 95.28,78.68 95.38,78.58 95.59,78.58 95.69,78.68 95.69,79.28 95.79,79.38 95.99,79.38 96.1,79.28 96.1,78.68 96.2,78.58 96.4,78.58 96.5,78.68 96.5,79.28 96.6,79.38 98.62,79.38 99.95,80.71 111.61,80.71 111.71,80.61 111.71,80.46 111.82,80.36 112.02,80.36 112.12,80.46 112.12,80.61 112.22,80.71 112.42,80.71 112.53,80.61 112.53,80.46 112.63,80.36 112.83,80.36 112.93,80.46 112.93,80.61 113.03,80.71 113.24,80.71 113.34,80.61 113.34,80.46 113.44,80.36 113.64,80.36 113.75,80.46 113.75,80.61 113.85,80.71 114.05,80.71 114.15,80.61 114.15,80.46 114.25,80.36 114.46,80.36 114.56,80.46 114.56,80.61 114.66,80.71 114.86,80.71 114.96,80.61 114.96,80.46 115.07,80.36 115.27,80.36 115.37,80.46 115.37,80.61 115.47,80.71 137.08,80.71 137.24,80.87 137.24,81.48 137.39,81.63 138.19,81.63 138.29,81.53 138.29,80.71 138.39,80.61 138.59,80.61 138.7,80.71 138.7,81.53 138.8,81.63 139.09,81.63 139.19,81.53 139.19,80.76 139.3,80.66 140.16,80.66 141.38,79.44 v1(141.38,78.96)
  BOTTOM w0.089: U1.AF1 34.48,68.16 34.27,68.38 34.27,69.74 34.7,70.17 34.7,70.65
  BOTTOM w0.102: v1(35.21,70.96) 34.82,70.96 34.7,70.83 34.7,70.65 ; v1(141.38,78.96) 141.3,79.04 F3R8.2 140.46,77.95 v2(140.46,77.94)
SPI_MISO: length 128.9
  IN3 w0.102: v1(133.49,84.26) 133.49,82.83 133.07,82.41 123.95,82.41 123.31,81.77 112.65,81.77 112.28,81.4 99.67,81.4 98.34,80.07 92.9,80.07 92.67,80.29 89.06,80.29 88.75,79.99 86.04,79.99 85.7,79.65 81.7,79.65 80.93,80.42 76.67,80.42 75.2,78.95 68.48,78.95 66.97,80.46 62.81,80.46 62.66,80.61 61.66,80.61 61.38,80.89 60.74,80.89 59.52,79.67 58.48,79.67 56.34,77.53 53.76,77.53 52.44,76.22 50.44,76.22 49.73,75.51 48.11,75.51 46.54,73.93 43.2,73.93 43.11,74.02 36.49,74.02 35.33,72.87 35.09,72.87 34.05,71.82 32.71,71.82 31.83,70.94 31.83,70.84 v1(31.54,70.55)
  BOTTOM w0.089: 31.07,68.93 31.07,68.57 31.41,68.23 31.58,68.23 31.89,67.92 31.89,66.32 32.19,66.02 U1.AA4
  BOTTOM w0.102: v1(31.54,70.55) 31.07,70.09 31.07,68.93 ; F3R7.1 136.63,89.18 v2(136.35,88.89) 136.35,90.49 136.2,90.64 134.24,90.64 134.01,90.42 134.01,89.84 134.73,89.12 134.73,86.46 133.49,85.22 v1(133.49,84.26)
SPI_MOSI: length 136.2
  IN3 w0.102: v1(142.01,79.01) 143.54,79.01 143.69,79.16 143.69,79.92 143.56,80.05 141.12,80.05 139.32,81.86 134.89,81.86 134.79,81.75 134.79,81.55 134.89,81.45 136.76,81.45 136.86,81.35 136.86,81.14 136.76,81.04 134.48,81.04 134.38,81.14 134.38,81.75 134.28,81.86 134.06,81.86 133.15,80.94 99.86,80.94 98.53,79.61 92.71,79.61 92.48,79.84 89.25,79.84 88.94,79.53 86.23,79.53 85.89,79.19 81.51,79.19 80.74,79.96 76.9,79.96 75.43,78.49 68.12,78.49 66.61,80 62.62,80 62.47,80.16 61.47,80.16 61.26,80.37 60.86,80.37 59.71,79.21 58.67,79.21 56.53,77.07 53.95,77.07 52.63,75.76 50.67,75.76 48.72,73.82 47.07,73.82 46.73,73.47 42.95,73.47 42.01,72.53 40.64,72.53 40.25,72.93 39.21,72.93 38.72,72.44 35.6,72.44 34.52,71.36 32.91,71.36 32.41,70.86 32.41,69.69 32.04,69.32 v1(31.48,69.32)
  BOTTOM w0.089: U1.AA2 32.52,67.44 32.52,68.05 31.91,68.66 31.91,69.15
  BOTTOM w0.102: v1(142.01,79.01) 142.01,78.1 v2(142.37,77.74) 143.26,77.74 143.84,78.32 F3R11.2 ; 31.91,69.15 31.74,69.32 v1(31.48,69.32)
SPI_WP#: length 8.3
  BOTTOM w0.102: v2(105.46,63.19) 105.21,63.44 104.31,63.44 103.86,63.89 103.86,67.2 104.28,67.62 R220.2 105.61,67.62 105.64,67.6 U11.3
SPI_WP_IO2: length 130.6
  IN3 w0.089: v1(31.17,64.77) 30.76,65.17 30.76,65.84 30.7,65.9 30.7,68.52 30.94,68.76 30.94,68.93
  IN3 w0.102: v1(136.78,85.34) 136.37,85.34 135.76,84.73 135.29,84.73 135.18,84.83 135.18,85.41 135.08,85.51 134.88,85.51 134.78,85.41 134.78,84.83 134.68,84.73 134.47,84.73 134.37,84.83 134.37,85.41 134.27,85.51 134.07,85.51 133.96,85.41 133.96,84.83 133.86,84.73 133.37,84.73 133.07,84.43 133.07,82.82 132.89,82.64 113.2,82.64 112.18,81.62 99.57,81.62 98.24,80.29 92.99,80.29 92.38,80.9 86.59,80.9 85.57,79.88 81.8,79.88 81.03,80.65 76.57,80.65 75.1,79.18 68.58,79.18 67.07,80.69 62.91,80.69 62.75,80.84 61.75,80.84 61.48,81.12 60.64,81.12 59.42,79.9 58.39,79.9 56.25,77.76 53.66,77.76 52.35,76.45 50.35,76.45 49.63,75.73 48.02,75.73 46.44,74.16 43.29,74.16 43.21,74.25 40.29,74.25 40.18,74.35 40.18,74.9 40.08,75 39.88,75 39.78,74.9 39.78,74.35 39.68,74.25 39.47,74.25 39.37,74.35 39.37,74.9 39.27,75 39.07,75 38.96,74.9 38.96,74.35 38.86,74.25 38.66,74.25 38.56,74.35 38.56,74.9 38.46,75 38.25,75 38.15,74.9 38.15,74.35 38.05,74.25 35.4,74.25 34.54,73.39 34.54,73.14 33.47,72.07 32.58,72.07 31.57,71.06 31.45,71.06 30.94,70.56 30.94,68.93
  BOTTOM w0.089: v1(31.17,64.77) 31.42,64.52 U1.Y6
  BOTTOM w0.102: F3R9.1 137.14,85.3 137.1,85.34 v1(136.78,85.34) 136.78,85.41 v2(136.25,85.95)
SPK_R_N_B: length 195.3
  TOP w0.381: v1(173.05,89.63) 172.59,89.17 v2(172.59,88.64)
  IN1 w0.381: v1(173.05,89.63) 172.14,89.63 171.65,90.11 150.19,90.11 149.68,89.6 142.72,89.6 141.48,88.36 133.83,88.36 132.69,89.5 99.86,89.5 99.14,88.78 99.14,88.29 98.7,87.85 94.9,87.85 94.01,88.74 75.53,88.74 73.46,86.68 73.46,85.55 72.59,84.68 67.35,84.68 66.82,85.21 64.2,85.21 63.73,84.74 58.62,84.74 58.17,85.2 58.17,86.64 56.68,88.13 55.22,88.13 54.49,88.87 53.39,88.87 52.78,88.26 40.28,88.26 38.42,90.11 24.13,90.11 22.23,88.21 19.11,88.21 17.1,86.2 16.41,86.2 15.5,85.29 11.59,85.29 10.77,84.47 10.77,84.36 v1(10.74,84.33)
  BOTTOM w0.254: v1(10.74,84.33) 9.89,84.33 9.31,83.74 CON10.12
  BOTTOM w0.279: 185.25,89.5 CON11.18
  BOTTOM w0.381: 185.25,89.5 184.46,90.29 173.71,90.29 v1(173.05,89.63)
SPK_R_P_B: length 194.5
  TOP w0.381: v1(173.94,89.63) 174.37,89.2 v2(174.37,88.56)
  IN1 w0.381: v1(11.56,84.44) 11.66,84.44 12.02,84.8 15.7,84.8 16.58,85.69 17.28,85.69 19.26,87.67 22.38,87.67 24.33,89.63 38.22,89.63 40.08,87.77 52.99,87.77 53.6,88.38 54.29,88.38 55.07,87.6 56.53,87.6 57.61,86.52 57.61,84.95 58.31,84.26 63.93,84.26 64.4,84.73 66.61,84.73 67.22,84.12 72.72,84.12 73.95,85.34 73.95,86.48 75.73,88.26 93.81,88.26 94.7,87.36 98.98,87.36 99.62,88.01 99.62,88.58 100.06,89.02 132.49,89.02 133.63,87.88 141.68,87.88 142.92,89.12 150.22,89.12 150.73,89.63 171.17,89.63 171.73,89.07 173.38,89.07 v1(173.94,89.63)
  BOTTOM w0.254: CON10.11 9.27,84.24 9.86,84.83 10.95,84.83 11.34,84.44 v1(11.56,84.44)
  BOTTOM w0.279: 184.75,89.11 CON11.17
  BOTTOM w0.381: 184.75,89.11 184.08,89.78 174.09,89.78 v1(173.94,89.63)
SPKR: length 63.7
  TOP w0.127: v1(30.38,81.03) 29.65,80.3 29.65,79.64 v2(30.15,79.14) 30.9,78.39 30.9,76.62 31.43,76.09 31.43,74.96 31.75,74.64 31.75,74.08 31.88,73.95 31.88,73.25 31.64,73.02 v1(31.64,72.75)
  IN1 w0.127: v1(5.21,89.07) 4.42,89.07 4.01,88.66 4.01,79.36 3.79,79.13 3.79,75.63 5.69,73.73 7.1,73.73 7.73,74.36 10.3,74.36 10.77,74.83 11.34,74.83 11.58,75.07 13.84,75.07 14.48,75.71 18.57,75.71 20.01,77.14 20.01,78.62 21.52,80.14 22.73,80.14 23.32,79.55 26.07,79.55 26.66,80.14 29.07,80.14 29.52,80.59 29.94,80.59 v1(30.38,81.03)
  BOTTOM w0.089: U1.V2 30.53,67.36 30.53,67.47 30.45,67.56 30.45,68.15
  BOTTOM w0.102: 30.86,71.62 30.28,71.03 30.28,68.32 30.45,68.15
  BOTTOM w0.127: v1(5.21,89.07) 5.12,89.07 4.79,88.74 CON10.32 ; 30.86,71.62 30.86,71.96 SR27.2 31.64,72.74 v1(31.64,72.75)
SRTC_RST#: length 11.9
  TOP w0.089: v1(42.15,64.05) 42.15,64.59 44.82,67.26 45.12,67.26 T3.1 47.68,69.82 R74.2
  TOP w0.102: R74.2 48.81,70.48 49.44,70.48 C51.1
  BOTTOM w0.089: U1.AV6 42.15,64.16 v1(42.15,64.05)
SUS_PWR_ACK_R: length 15.9
  IN2 w0.089: v1(42.7,68.72) 42.36,69.07 42.2,69.07 40.33,70.93 40.29,70.93
  IN2 w0.102: 40.29,70.93 v1(37.8,73.42)
  BOTTOM w0.089: U1.AV4 41.66,65.99 41.52,66.13 41.52,66.61 41.71,66.79 41.93,66.79 42.16,67.02 42.16,68.05 42.7,68.59 v1(42.7,68.72)
  BOTTOM w0.102: v2(39.57,76.42) 39.57,76.22 39.12,75.76 39.12,74.77 R91.2 39.09,73.86 38.23,73.86 v1(37.8,73.42) 38.03,73.19 PR3.1
SUS_PWRGD: length 70
  TOP w0.254: v1(137.43,76.29) 137.43,77.35 138.12,78.03 R60465.1 ; v1(129.9,86.62) 129.79,86.51 129.79,83.61 130.35,83.05 130.35,78.02 v1(130.51,77.87) 130.51,74.46 v2(130.42,74.38) 130.17,74.13 130.17,69.85 130.51,69.51 v1(131.01,69.51)
  IN1 w0.254: v1(129.9,86.62) 129.9,86.86 129.64,87.11 128.93,87.11 127.71,85.89 126.16,85.89 125.82,86.24 125.82,87.28 125.29,87.81 124.98,87.81 124.2,88.6 115.97,88.6 v1(115.75,88.37) ; v1(121.14,62.29) 121.14,63.49 120.07,64.56 120.07,67.15 v1(119.57,67.64)
  IN2 w0.254: v1(137.43,76.29) 137.43,77.26 136.35,78.34 130.98,78.34 v1(130.51,77.87)
  IN3 w0.254: v1(131.01,69.51) 130.56,69.51 129.26,70.81 121.85,70.81 119.57,68.53 v1(119.57,67.64)
  BOTTOM w0.178: v1(115.75,88.37) 115.6,88.22 115.6,87.55 115.38,87.33 U10.67
  BOTTOM w0.203: PR144.2 120.96,62.11 v1(121.14,62.29) 121.28,62.43 PU6.7
SUS_STAT#: length 194.2
  TOP w0.102: v1(83.94,83.43) 84.14,83.63 84.14,87.39 83.01,88.52 70.55,88.52 70.12,88.09 63.84,88.09 63.41,87.66 58.31,87.66 55.32,84.66 49.93,84.66 48.21,82.95 47.17,82.95 45.99,81.77 45.99,80.11 45.18,79.3 43.46,79.3 43.35,79.2 43.35,78.15 42.46,77.25 40.84,77.25 39.41,75.82 39.41,72.97 38.91,72.47 38.91,71.77 38.41,71.27 PR15.2 ; v1(91.26,69.77) 91.7,69.33 91.7,68.78 93.24,67.23 93.24,41.14 89.99,37.89 89.99,37.2 89.69,36.9 89.69,28.72 89.18,28.21 89.18,23.09 89.69,22.58 89.69,21.73 89.05,21.09 89.05,18.67 v1(90.69,17.04) ; v1(118.87,21.35) 121.9,24.38 v2(123.88,24.38) 129.39,24.38 132.64,27.63 132.64,30.65 132.17,31.12 132.17,32.25 R164.2 132.17,33.13 U9.28
  IN1 w0.102: v1(90.69,17.04) 90.68,17.05 92.88,17.05 94.02,18.19 94.82,18.19 97.09,15.92 100.34,15.92 105.09,20.67 118.19,20.67 v1(118.87,21.35)
  BOTTOM w0.102: v1(83.94,83.43) 83.94,83.09 82.36,81.51 82.36,77.98 84.17,76.17 86.97,76.17 87.87,75.28 87.87,74.31 89.24,72.94 89.24,72.34 90.88,70.7 90.88,70.15 v1(91.26,69.77)
SUS_STAT#_R: length 5.8
  TOP w0.089: PR15.1 38.02,69.76 36.93,68.67 36.93,68.45 36.15,67.66 36.15,66.7 v1(35.6,66.16)
  BOTTOM w0.089: v1(35.6,66.16) 35.3,65.85 U1.AG4
SUSACK#_R: length 8.3
  BOTTOM w0.089: U1.AK2 36.73,67.38 36.44,67.67 36.44,68.18 36.83,68.57 36.83,68.99
  BOTTOM w0.102: 36.83,68.99 36.88,69.04 36.88,70.21 38.03,71.36 PR3.2 37.62,71.81 37.52,71.91 37.52,72.84 37.38,72.98 37.38,73.91 v2(37.59,74.12)
SUSB_EC#: length 360.2
  TOP w0.102: PR180.1 121.63,14.43 121.85,14.22 v1(121.85,12.64) v2(123.57,12.64) 125.56,12.64 129.49,16.57 129.49,18.64 129.97,19.12 PQ31.2 ; v1(156.41,62.77) 156.41,61.54 156.69,61.26 156.69,60.16 156.34,59.81 154.15,59.81 153.96,60.01 D9200.2 153.96,62.29 153.26,62.98 v1(153.26,63.82) R9204.1 ; PR163.1 113.14,67.23 113.29,67.23 113.6,67.53 v1(114.37,67.53) ; v1(116.66,35.78) 115.67,34.79 113.84,34.79 112.88,33.82 112.88,22.19 v1(113.39,21.68) ; Q28.1 171.11,71.22 172,70.34 v1(172,69.64) ; v1(119.64,74.9) 119.64,73.75 119.29,73.41 119.29,69.73 119.97,69.05 119.97,68.75 v1(120.55,68.17)
  IN1 w0.102: v1(121.85,12.64) 120.68,13.81 109.73,13.81 103.53,7.61 93.43,7.61 93.19,7.38 91.53,7.38 89.5,5.35 86.46,5.35 84.61,3.5 65.37,3.5 63.96,4.91 60.39,4.91 59.03,3.55 55.55,3.55 v1(53.29,5.81) ; v1(172,69.64) 171.49,70.15 170.73,70.15 170.37,69.79 166.93,69.79 165.61,68.47 165.61,67.02 164.34,65.75 162.08,65.75 159.09,62.77 v1(156.41,62.77) ; v1(116.66,35.78) 112.22,40.23 112.22,43.78 110.21,45.79 110.21,57.5 111.15,58.44 111.15,60.17 111.34,60.35 111.73,60.35 112.47,61.1 112.47,62.09 112.78,62.4 113.24,62.4 114.84,60.8 116.31,60.8 v1(117.45,61.94)
  IN2 w0.102: v1(112.08,86.69) 111.71,86.33 99.17,86.33 97.96,87.54 94.71,87.54 93.85,88.4 74.94,88.4 73.51,86.96 66.94,86.96 66.34,86.36 60.39,86.36 59.76,85.73 v1(59.31,85.73)
  IN3 w0.102: v1(153.26,63.82) 153.26,66.29 152.07,67.48 152.07,68.42 151.95,68.54 145.86,68.54 143.89,70.51 132.73,70.51 131.9,69.69 131.9,69.52 131.27,68.89 128.59,68.89 127.93,69.55 126.56,69.55 126.53,69.52 125.69,69.52 125.06,70.16 122.34,70.16 120.55,68.37 v1(120.55,68.17) 120.55,66.96 119.45,65.87 118.96,65.87 118.52,66.31 115.7,66.31 114.48,67.53 v1(114.37,67.53)
  BOTTOM w0.102: v1(121.85,12.64) 120.98,13.5 120.07,13.5 113.39,20.19 v1(113.39,21.68) ; v1(117.45,61.94) 117.24,62.15 117.24,62.42 117.58,62.76 117.58,67.3 117.35,67.53 v1(114.37,67.53) ; v1(53.29,5.81) 53.11,5.99 52.54,5.99 52.4,5.85 46.9,5.85 45.94,6.81 PC177.1 45.94,8.13 45.96,8.16 PU9.3 ; PR200.1 56.34,89.96 59.45,89.96 59.97,89.43 59.97,88.18 59.31,87.52 v1(59.31,85.73) ; v1(112.08,86.69) 110.27,86.69 106.69,83.12 106.69,82.11 106.91,81.89 107.41,81.89 107.6,82.08 107.6,82.51 107.84,82.75 109.47,82.75 109.73,82.49 109.73,82.18 110.64,81.27 112.83,81.27 113.17,80.93 U10.83 115.55,80.93 115.98,80.51 115.98,79.19 116.27,78.9 116.52,78.9 117.1,78.33 117.1,77.82 117.27,77.64 117.48,77.64 117.53,77.58 R224.1 118.78,76.33 119.64,75.48 v1(119.64,74.9)
SUSB_ON#: length 19.3
  TOP w0.102: Q30.2 170.24,68.9 170.5,69.16 ; R314.2 168.3,71.24 168.05,71.49 168.05,72.56 168.33,72.84 Q28.3 ; Q29.2 173.16,65.6 173,65.76 173,66.23 173.16,66.39 Q29.5 173.16,67.53 173.08,67.62 Q27.2 173.08,68.95 172.87,69.16 ; Q27.5 173.08,69.36 172.87,69.16 ; 172.87,69.16 172.85,69.13 170.52,69.13 170.5,69.16 ; 170.5,69.16 170.5,69.53 170.24,69.78 Q30.5 170.24,72.63 170.04,72.84 Q28.3 ; Q28.3 v2(169.03,75.1)
SUSB_POWER_G_B: length 73.7
  TOP w0.381: PQ31.4 129.48,19.77 129.41,19.7 v2(127.33,19.7) 126.63,19.7 126.52,19.59 PR207.1 125.49,19.59 v1(125.2,19.3)
  IN2 w0.381: v1(125.2,19.3) 120.3,24.2 120.3,32.3 120.98,32.99 120.98,40.61 122.35,41.98 122.35,46.12 123.22,46.98 123.22,58.11 124.94,59.83 v1(126.26,59.83) 126.26,60.32 125,61.59 123.5,61.59 122.28,60.37 121.77,60.37 120.04,58.64 120.04,57.88 119.52,57.36 114.23,57.36 113.41,56.53 112.65,56.53 111.35,55.23 v1(111.1,55.23)
  BOTTOM w0.381: PR198.1 111.42,55.23 v1(111.1,55.23) ; PR195.1 127.58,59 126.74,59.83 v1(126.26,59.83)
SUSC_EC#: length 174.8
  TOP w0.102: v1(114.37,68.26) 114.04,68.26 113.3,67.52 110.5,67.52 110.24,67.25 110.24,66.88 PR168.1 ; PQ32.2 127.26,59.22 127,59.48 127,62.02 126.46,62.57 126.46,65.38 125.76,66.08 124.31,66.08 123.47,66.92 120.85,66.92 v2(120.65,66.72) 120.16,66.24 119.33,66.24 v1(119.28,66.29) ; Q32.1 178.86,74.49 178.45,74.9 177.55,74.9 175.36,77.08 171.26,77.08 v1(170.26,76.08)
  IN1 w0.102: v1(110.16,82.34) 110.53,81.97 114.15,81.97 114.85,82.67 130.07,82.67 132.54,80.21 132.54,76.95 132.74,76.75 146.51,76.75 146.99,76.27 152.41,76.27 153.29,77.14 162.17,77.14 164.28,75.04 167.91,75.04 168.95,76.08 v1(170.26,76.08) ; v1(119.28,66.29) 119.28,66.54 118.31,67.51 115.13,67.51 v1(114.37,68.26) ; v1(169.37,71.34) 168.42,71.34 167.09,72.67 164.39,72.67 163.94,72.22 163.49,72.22 161.61,70.34 158.1,70.34 156.89,69.13 154.46,69.13 v1(153.28,67.95)
  IN3 w0.102: v1(119.28,66.29) 119.52,66.29 119.99,66.76 119.99,68.22 122.13,70.36 125.16,70.36 125.8,69.73 126.37,69.73 126.39,69.75 128.05,69.75 128.72,69.09 131.19,69.09 131.7,69.6 131.7,69.77 132.64,70.72 143.97,70.72 145.94,68.75 152.44,68.75 153.24,67.95 v1(153.28,67.95)
  BOTTOM w0.102: v1(169.37,71.34) 169.88,71.34 170.24,71.7 170.24,75.33 170.23,75.34 170.23,76.05 v1(170.26,76.08) ; v1(110.16,82.34) 110.97,81.53 113.18,81.53 113.38,81.33 U10.82 115.56,81.33 116.04,80.85 R225.1
SUSC_ON#: length 15.6
  TOP w0.102: R320.2 180.71,71.2 v2(181.33,71.82) ; R320.2 179.2,71.2 179.09,71.31 Q32.3 177.28,71.31 175.85,72.74 175.19,72.74 ; R320.2 178.99,70.02 177.61,70.02 176.96,69.37 Q33.1 ; 175.19,72.74 174.94,72.48 Q31.2 ; 175.19,72.74 174.94,72.99 Q31.5
SUSCLK: length 232
  TOP w0.089: PR221.2 35.11,70.26 v1(35.15,70.3)
  TOP w0.102: v1(114.15,21.61) v2(114.15,31.61) 114.15,33.72 v1(114.12,33.75) ; SC1.1 34.05,68.68 33.89,68.85 33.89,70.07 34.07,70.26 PR221.2
  IN1 w0.102: v1(93.85,79.16) 94.82,78.2 94.82,77.96 96.94,75.84 98.06,75.84 99.29,74.61 99.29,70.95 102.42,67.82 104.48,67.82 107.88,64.42 107.88,60.4 108.47,59.82 108.47,58.82 108.24,58.6 108.24,42.09 107.23,41.07 107.23,37.64 108.3,36.57 110.96,36.57 113.78,33.75 v1(114.12,33.75) ; v1(171.17,54.42) 169.85,53.1 169.85,47.73 167.53,45.4 167.53,41.69 165.63,39.79 164.66,39.79 161.05,36.19 158.7,36.19 155.86,33.34 153.27,33.34 149.46,29.53 143.99,29.53 136.68,22.22 129.24,22.22 128.05,21.02 121.44,21.02 120.68,21.79 118.42,21.79 117.67,21.04 114.72,21.04 v1(114.15,21.61) 113.74,21.2 v1(110.19,21.2)
  IN3 w0.102: v1(35.15,70.3) 34.8,70.65 34.8,71.29 35.59,72.08 40.83,72.08 41.06,72.31 46.03,72.31 47.32,73.59 49.68,73.59 50.36,74.27 50.36,74.99 50.9,75.53 52.73,75.53 54.04,76.84 56.63,76.84 58.77,78.99 60.72,78.99 61.66,79.93 62.38,79.93 62.53,79.77 66.51,79.77 68.02,78.26 75.99,78.26 76.69,78.97 85.59,78.97 86.1,78.45 86.7,78.45 87.55,79.3 91.66,79.3 92.03,78.94 93.63,78.94 v1(93.85,79.16)
  BOTTOM w0.102: v1(110.19,21.2) 110.15,21.2 104.53,15.58 CONSATA.68 ; CONWIFI.50 172.48,54.1 172.38,54 171.59,54 v1(171.17,54.42)
SUSCLK_GPIO62: length 5.5
  TOP w0.089: PR221.1 34.38,68.84 34.5,68.72 34.5,65.28 v1(33.97,64.75)
  BOTTOM w0.102: v1(33.97,64.75) 34.2,64.52 U1.AE6
SUSWARN#: length 76.9
  TOP w0.102: v1(108.05,76.65) 108.05,76.92 107.89,77.08 107.29,77.08 107.01,77.36 v2(106.68,77.36)
  IN2 w0.102: v1(39.94,75.76) 40.35,75.35 42.39,75.35 43.25,76.21 45.29,76.21 45.65,75.85 53.68,75.85 53.92,76.09 58.17,76.09 59.11,75.15 64.09,75.15 64.35,75.41 66.43,75.41 67.06,76.04 77.55,76.04 78.18,75.41 81.26,75.41 81.46,75.61 81.46,75.84 81.69,76.06 89.02,76.06 90.29,77.34 95.53,77.34 96.5,76.37 101.43,76.37 101.59,76.21 107.6,76.21 v1(108.05,76.65)
  BOTTOM w0.102: U10.108 108.58,74.77 108.44,74.91 108.44,75.85 108.05,76.24 v1(108.05,76.65) ; v1(39.94,75.76) 39.56,75.38 R91.1
SYS_PRES#: length 10.7
  BOTTOM w0.102: CON8.6 125.5,72.14 125.21,71.85 124.92,71.85 124.54,71.47 v2(124.08,71.47) 123.94,71.33 R348.1 122.81,71.33 122.79,71.35 R347.2 121.64,70.87 121.64,70.22 121.31,69.89 120.88,69.89 120,69.01 Q38.3
SYS_PWROK: length 323.7
  TOP w0.102: GR4.2 58.64,3.98 56.39,3.98 v1(55.45,4.92) ; v1(90.86,82.69) 90.86,81.6 92.48,79.98 SC2.1 92.69,80.55 92.69,81.07 93.22,81.6 R187.2 ; v1(78.94,5.17) 78.78,5 XDP1.47
  IN1 w0.102: v1(55.45,4.92) 56.41,3.95 58.27,3.95 59.63,5.31 64.13,5.31 65.29,4.16 75.69,4.16 76.29,4.75 78.53,4.75 v1(78.94,5.17)
  IN2 w0.102: v1(90.86,82.69) 91.28,83.11 94.3,83.11 94.87,82.54 97.99,82.54 98.82,83.36 105.93,83.36 106.12,83.55 110.4,83.55 111.23,82.73 111.23,82.48 111.48,82.23 112.92,82.23 113.44,82.75 120.3,82.75 120.77,83.21 130.36,83.21 130.64,83.49 132.8,83.49 133.06,83.23 137.34,83.23 137.85,83.74 139.7,83.74 140.42,83.02 142.76,83.02 145.4,80.38 150.26,80.38 151.76,78.88 164.12,78.88 166.16,76.85 166.16,75.19 165.78,74.81 165.78,73.79 165.41,73.42 165.41,64.91 165,64.51 165,59.53 162.24,56.77 162.24,39.86 v1(162.56,39.54)
  IN3 w0.102: v1(37.39,77.97) 37.39,77.97 38.33,77.97 38.61,78.26 39.51,78.26 40.16,77.61 46.73,77.61 47.63,78.51 50.71,78.51 51.41,79.2 53.59,79.2 54.03,79.65 55.03,79.65 55.83,80.45 56.67,80.45 57.58,81.35 58.82,81.35 60.04,82.57 61.83,82.57 62.87,83.61 64.38,83.61 65.56,82.43 74.49,82.43 74.82,82.1 79.52,82.1 80,82.58 80.59,82.58 81.27,81.89 82.52,81.89 83.03,82.4 86.19,82.4 86.67,82.88 87.31,82.88 88.04,82.15 90.31,82.15 v1(90.86,82.69) ; v1(78.94,5.17) 79.83,5.17 81.42,6.76 84.77,6.76 87.21,4.32 92.03,4.32 93.75,6.05 94.55,6.05 97.64,9.14 98.75,9.14 99.39,9.77 102.15,9.77 104.63,12.25 109.35,12.25 116.83,19.73 124,19.73 127.03,22.75 v1(127.61,22.75)
  BOTTOM w0.102: PR10.1 36.16,73.42 37.15,74.4 37.15,77.74 v1(37.39,77.97) ; v1(127.61,22.75) 136.22,22.75 139.85,26.38 146.89,26.38 153.95,33.44 153.95,35.33 158.16,39.54 v1(162.56,39.54) ; v2(55.45,4.16) v1(55.45,4.92)
SYS_PWROK_R: length 5.3
  BOTTOM w0.089: 35.65,69.19 35.51,69.06 35.51,67.44 U1.AG2
  BOTTOM w0.102: 35.65,69.19 35.83,69.37 35.83,70.36 v2(36.22,70.76) 36.22,71.18 36.16,71.24 PR10.2
TD_IREF: length 7.8
  BOTTOM w0.089: 17.3,58.34 v2(18.16,57.47) ; 17.3,59.07 17.93,59.07 19.02,60.16 20.8,60.16 20.98,60.34 U1.B12
  BOTTOM w0.102: 17.3,59.07 17.04,59.07 16.8,59.32 HR45.2 17.04,58.78 17.04,58.59 17.3,58.34
TESTLOW1: length 9
  BOTTOM w0.089: 17.3,44.75 17.48,44.92 v2(17.48,45.51) 17.86,45.89 21.54,45.89 21.81,46.16 U1.C35
  BOTTOM w0.102: CKRN1.3 16.98,42.55 17.12,42.69 17.12,44.57 17.3,44.75
TESTLOW2: length 9
  BOTTOM w0.089: 19.02,46.14 19.31,46.14 19.86,46.7 20.23,46.7 20.28,46.65 21.29,46.65 21.46,46.83 21.46,47.02 21.72,47.28 21.9,47.28 U1.C34
  BOTTOM w0.102: CKRN1.1 16.57,43.96 v2(16.33,44.2) 16.33,44.54 16.94,45.15 16.94,45.79 17.3,46.14 19.02,46.14
TESTLOW3: length 10.4
  TOP w0.089: 39.51,70.45 39.51,70.03 39.3,69.82 38.94,69.82 38.46,69.33 v2(38.46,69.16) 38.13,68.83 37.59,68.83 37.29,68.53 37.29,68.3 36.52,67.54 36.52,64.88 36.38,64.74 36.38,64.26 37.29,63.34 v1(37.29,63.08)
  TOP w0.102: 39.51,70.45 CKRN2.1
  BOTTOM w0.089: v1(37.29,63.08) 37.29,63.11 36.96,63.43 U1.AK8
TESTLOW4: length 10.8
  TOP w0.089: v1(37.95,63.09) 37.4,63.64 37.24,63.64 36.56,64.33 36.56,64.66 36.7,64.81 36.7,67.04 v2(37.26,67.6) ; 39.58,69.71 40.16,70.28 40.16,70.45
  TOP w0.102: 40.16,70.45 CKRN2.3 ; 39.58,69.71 39.58,69.06 38.13,67.6 v2(37.26,67.6)
  BOTTOM w0.089: U1.AL8 37.61,63.43 v1(37.95,63.09)
THRO_CPU: length 134.8
  IN3 w0.102: v1(94.24,67.91) 93.8,67.91 91.8,65.91 91.8,59.94 89.64,57.77 89.64,54.43 91.49,52.57 91.49,48.86 89.64,47 89.64,29.25 88.55,28.16 87.83,28.16 84.63,24.96 83.72,24.96 82.59,23.83 80.09,23.83 77.48,21.23 76.97,21.23 75.86,20.12 70.49,20.12 70.19,19.83 70.19,19.63 69.09,18.52 59.45,18.52 59.34,18.63 48.01,18.63 45.37,21.27 41.56,21.27 41,21.84 38.91,21.84 38.37,22.37 38.37,22.41 v1(38.13,22.65)
  BOTTOM w0.102: HR6.1 42.89,17.62 43.45,18.18 43.45,18.79 42.61,19.63 39.45,19.63 v2(38.74,20.34) 38.13,20.95 v1(38.13,22.65) ; R181.2 94.97,87.42 94.4,86.85 93.82,86.85 92.89,85.92 92.89,85.62 93.09,85.41 93.09,84.93 92.91,84.75 92.08,84.75 91.9,84.57 91.9,84.42 92.53,83.79 92.53,80.69 93.19,80.03 93.19,78.82 94.07,77.94 94.07,74.59 94.07,74.07 93.47,73.47 93.47,72.22 93.95,71.74 94.07,71.74 R176.1 94.81,68.48 v1(94.24,67.91)
TOUCH_DET_CBL#: length 22
  BOTTOM w0.089: 25.68,70.34 25.68,69.28 26.02,68.94 26.28,68.94 26.53,68.69 26.53,68.24 26.52,68.24 26.52,67.04 26.2,66.71 U1.K3
  BOTTOM w0.102: CN1.1 23,82.35 22.93,82.28 22.63,82.28 22.38,82.52 D10.1 21.8,82.01 22.06,81.74 23.2,81.74 23.56,81.38 R425.2 25.11,80.66 25.11,79.72 25.11,79.72 v2(25.11,78.73) 25.11,77.92 25.63,77.4 25.63,76.84 24.93,76.15 24.93,75.8 25.2,75.53 25.2,75.15 25.4,74.94 25.4,71.26 25.68,70.98 25.68,70.34
TOUCH_ON#: length 77.3
  TOP w0.102: v2(41,87.7) 40.95,87.75 v1(39.31,87.75)
  IN1 w0.102: v1(39.31,87.75) 39.63,87.43 53.13,87.43 53.74,88.04 54.14,88.04 54.94,87.24 56.4,87.24 57,86.64 57,84.93 58.02,83.91 64.48,83.91 67.27,81.12 73.98,81.12 74.78,81.92 74.78,85.75 76.55,87.52 80.24,87.52 80.54,87.83 89.66,87.83 90.55,86.94 v1(90.55,86.94)
  BOTTOM w0.102: U10.33 100.58,89.17 100.41,88.99 98.99,88.99 98.18,89.79 92.95,89.79 90.55,87.39 v1(90.55,86.94) ; v1(39.31,87.75) 39.31,87.72 38.78,88.25 Q19.1
TOUCH_ON#_D: length 6.1
  BOTTOM w0.102: T33.1 40.82,87.01 R275.2 41.4,88.21 40.92,88.21 40.67,88.46 40.67,89.16 C114.1 40.68,89.59 40.29,89.2 Q19.3
TP_A6: length 3.4
  TOP w0.089: v1(18.87,64.11) 18.02,64.97 T70.1
  BOTTOM w0.089: U1.A6 19.76,64.05 19.7,64.11 v1(18.87,64.11)
TP_A49: length 2.9
  TOP w0.102: v1(19.58,38.18) 19.72,38.04 21.06,38.04 HT91.1
  BOTTOM w0.114: v1(19.58,38.18) 19.72,38.05 U1.A49
TP_A53: length 10
  BOTTOM w0.089: 17.3,34.23 18.07,35 18.07,35.44 18.6,35.98 20.08,35.98 20.51,35.54 U1.A53
  BOTTOM w0.102: HT87.1 13.87,34.03 17.09,34.03 17.3,34.23
TP_AB21: length 7.5
  TOP w0.089: v1(32.82,55.57) 33.12,55.26 33.12,53.03 31.78,51.68 ST3.1
  BOTTOM w0.089: U1.AB21 v1(32.82,55.57)
TP_AC20: length 4.3
  TOP w0.089: PT4.1 32.34,59.68 32.34,58.04 v1(32.56,57.82)
  BOTTOM w0.089: v1(32.56,57.82) 32.91,57.82 33.09,57.63 33.09,56.75 U1.AC20
TP_AD2: length 4.2
  BOTTOM w0.089: v1(33.48,69.57) 34.06,70.16 T63.1 ; 33.64,68.2 33.85,68.2 34.01,68.04 34.01,67.62 33.73,67.34 U1.AD2
  BOTTOM w0.102: v1(33.48,69.57) 33.07,69.17 33.07,68.77 33.64,68.2
TP_AD4: length 3
  TOP w0.089: T8.1 32.21,67.4 32.21,66.59 v1(32.6,66.2)
  BOTTOM w0.089: U1.AD4 33.34,66.2 v1(32.6,66.2)
TP_AF2: length 3
  TOP w0.089: v1(33.48,68.94) 33.11,69.31 T62.1
  BOTTOM w0.089: v1(33.48,68.94) 33.48,68.91 34.19,68.2 34.19,67.66 34.48,67.38 U1.AF2
TP_AF3: length 5.6
  TOP w0.089: v1(35.05,69.66) 35.46,69.26 35.46,68.43 H19.1
  BOTTOM w0.089: v1(35.05,69.66) 34.47,69.08 34.47,68.44 34.76,68.15 34.76,67.01 34.52,66.76 U1.AF3
TP_AF20: length 4.4
  TOP w0.089: ST4.1 32.31,56.28 33.32,57.29 v1(33.84,57.29)
  BOTTOM w0.089: v1(33.84,57.29) 34.15,56.97 34.21,56.91 34.75,56.91 U1.AF20
TP_AL11: length 2.2
  TOP w0.089: v1(36.88,62.6) 36.58,62.91 AT6.1
  BOTTOM w0.089: U1.AL11 37.48,61.71 37.3,61.71 36.96,62.06 36.96,62.53 v1(36.88,62.6)
TP_AV10: length 9
  BOTTOM w0.089: U1.AV10 41.94,62.14 42.19,61.9 43.47,61.9 43.64,62.07 43.65,62.07 43.75,62.17 44.7,62.17 44.73,62.15 47.75,62.15
  BOTTOM w0.102: AT3.1 49.94,62.15 47.75,62.15
TP_AW10: length 6
  BOTTOM w0.089: 47.75,62.98 47.32,62.55 43.62,62.55 43.54,62.47 42.78,62.47 U1.AW10
  BOTTOM w0.102: 47.75,62.98 AT2.1
TP_AY8: length 3.2
  BOTTOM w0.089: U1.AY8 45.85,62.93 AT4.1
TP_B9: length 6.1
  TOP w0.089: 17.22,62.07 v1(17.39,62.23)
  TOP w0.102: T65.1 16.92,61.76 17.22,62.07
  BOTTOM w0.089: v1(17.39,62.23) 17.78,62.63 17.98,62.63 18.39,63.03 18.95,63.03 19.33,62.65 19.89,62.65 19.98,62.74 20.65,62.74 21.16,62.23 U1.B9
TP_B49: length 4.1
  TOP w0.102: HT92.1 19.54,38.66 19.43,38.66 v1(18.95,38.18)
  BOTTOM w0.089: v1(18.95,38.18) 19.02,38.18 19.45,37.75 20.66,37.75 20.96,38.05 U1.B49
TP_B50: length 3.4
  TOP w0.102: HT86.1 19.36,37.1 19.15,37.3 v1(19,37.3)
  BOTTOM w0.089: v1(19,37.3) 20.02,37.3 20.1,37.38 21.39,37.38 U1.B50
TP_B54: length 6.2
  BOTTOM w0.089: 19,35.59 19.62,35.59 20.24,34.98 U1.B54
  BOTTOM w0.102: 19,35.59 18.74,35.59 18.44,35.29 18.44,33.88 HT84.1
TP_C46: length 5.5
  BOTTOM w0.089: U1.C46 21.92,39.99 21.66,39.74 21.5,39.49 21.5,39.47 21.42,39.29 21.4,39.26 21.32,39.18 21.29,39.16 21.21,39.14 21.12,39.14 20.89,39.22 20.72,39.22 20.56,39.11 20.3,39.11 20.25,39.16 19.8,39.16 19.42,38.78 18.37,38.78 18.09,39.06 HT90.1
TP_C47: length 5
  TOP w0.102: HT89.1 17.86,38.83 v1(18.31,38.37)
  BOTTOM w0.089: U1.C47 21.92,39.32 21.92,39.24 21.79,39.11 21.52,39.11 21.48,39.07 21.37,39 21.23,38.96 21.09,38.96 20.86,39.04 20.77,39.04 20.58,38.9 20.22,38.9 20.16,38.96 19.86,38.96 19.5,38.6 18.54,38.6 v1(18.31,38.37)
TP_C49: length 4.6
  BOTTOM w0.089: HT85.1 17.93,37.76 19.18,37.76 19.38,37.56 21.11,37.56 21.6,38.05 U1.C49
TP_C50: length 9.3
  BOTTOM w0.089: U1.C50 21.96,37.48 21.58,37.11 21.5,36.98 21.5,36.96 21.42,36.78 21.4,36.75 21.32,36.67 21.29,36.65 21.21,36.63 21.12,36.63 20.94,36.69 20.69,36.69 20.31,36.43 19,36.43 ; 18.53,36.43 17.69,35.59
  BOTTOM w0.102: 17.69,35.59 17.69,35.2 16.95,34.46 15.01,34.46 HT82.1 ; 19,36.43 18.53,36.43
TP_C51: length 10.2
  BOTTOM w0.089: 18.83,36.24 20.35,36.24 20.42,36.29 20.75,36.51 20.91,36.51 21.09,36.46 21.23,36.46 21.37,36.49 21.43,36.53 21.81,36.91 U1.C51
  BOTTOM w0.102: 18.83,36.24 18.6,36.24 17.88,35.52 17.88,35.1 17.01,34.23 HT81.1
TP_C53: length 7.6
  BOTTOM w0.089: 19,35.79 19.7,35.79 20.25,35.24 21.32,35.24 21.62,35.54 U1.C53
  BOTTOM w0.102: 19,35.79 18.68,35.79 18.25,35.37 18.25,34.9 17.18,33.82 16.09,33.82 HT83.1
TP_D61: length 5.4
  TOP w0.102: HT1.1 21.46,26.79 21.46,27.02 v1(20.72,27.77)
  BOTTOM w0.089: U1.D61 22.03,30.48 21.71,30.15 21.11,30.15 20.91,29.95 20.91,29.58 20.72,29.4 v1(20.72,27.77)
TP_DC_TEST_A4: length 3.1
  TOP w0.089: v1(18.7,67.2) 18.99,67.2 HT47.1
  BOTTOM w0.089: v1(18.7,67.2) 19.98,65.91 U1.A4
TP_DC_TEST_A60: length 10.2
  BOTTOM w0.089: U1.A60 20.27,31.08 19.49,30.3 19.49,29.41 18.73,28.65 18.73,25.37
  BOTTOM w0.102: 18.73,25.37 18.73,22.43 HT49.1
TP_DC_TEST_A62: length 10.6
  BOTTOM w0.089: U1.A62 20.32,29.57 20.32,27.5 20.63,27.19 20.63,25.37
  BOTTOM w0.102: 20.63,25.37 20.63,24.96 19.08,23.41 HT51.1
TP_DC_TEST_AV1: length 3.1
  TOP w0.089: HT52.1 42.69,69.52 v1(42.69,69.36)
  BOTTOM w0.089: v1(42.69,69.36) 42.27,68.94 42.27,68.6 41.83,68.16 U1.AV1
TP_DC_TEST_AW1: length 3.4
  TOP w0.089: v1(43.29,69.16) 43.55,68.9 43.58,68.9 44.06,68.42 HT53.1
  BOTTOM w0.089: v1(43.29,69.16) 43.29,68.54 U1.AW1
TP_DC_TEST_AW63: length 3.6
  BOTTOM w0.089: U1.AW63 43.89,27.85 HT54.1
TP_DC_TEST_AY60: length 5.8
  BOTTOM w0.089: U1.AY60 43.44,31.06 44.11,30.39 46.49,30.39 46.95,30.85 46.95,31.79 HT48.1
TP_DC_TEST_B2: length 3.8
  TOP w0.089: v1(18.44,68.27) 18.72,68.55 HT50.1
  BOTTOM w0.089: U1.B2 20.69,67.63 19.86,67.63 19.23,68.27 v1(18.44,68.27)
TP_E2: length 4.9
  TOP w0.089: ST27.1 20.88,69.92 v1(21.13,69.66)
  BOTTOM w0.089: U1.E2 23.24,67.42 23.37,67.56 23.37,68.03 22.95,68.44 22.35,68.44 v1(21.13,69.66)
TP_E13: length 2.5
  TOP w0.089: ST2.1 21.79,61.8 v1(22.76,60.84)
  BOTTOM w0.089: v1(22.76,60.84) 22.74,60.84 23.13,60.45 U1.E13
TP_E15: length 2.5
  TOP w0.089: ST1.1 22.02,60.32 23.09,60.32 v1(23.44,59.96)
  BOTTOM w0.089: v1(23.44,59.96) 23.13,59.65 U1.E15
TP_F1: length 4.2
  TOP w0.089: v1(22.3,69.44) 23.22,69.44 ST22.1
  BOTTOM w0.089: v1(22.3,69.44) 22.64,69.44 23.95,68.13 U1.F1
TP_F2: length 3.7
  TOP w0.089: ST19.1 23.01,68.85 v1(22.63,68.85)
  BOTTOM w0.089: v1(22.63,68.85) 22.8,68.85 23.61,68.04 23.61,67.53 U1.F2
TP_F3: length 6.2
  BOTTOM w0.089: U1.F3 24.29,66.76 24.29,67.35 24.27,67.36 24.27,68.05 23.7,68.63 23.7,69.92 23.12,70.5 21.97,70.5 21.82,70.65
  BOTTOM w0.102: 21.82,70.65 ST20.1
TP_F4: length 1.3
  TOP w0.089: ST24.1 23.78,65.99 v1(23.6,66.17)
  BOTTOM w0.089: v1(23.6,66.17) 23.92,65.85 U1.F4
TP_G2: length 7
  BOTTOM w0.089: 23.27,70.65 23.88,70.05 23.88,68.7 24.45,68.13 24.45,67.59 24.74,67.31 U1.G2
  BOTTOM w0.102: ST28.1 21.67,72 22.91,70.76 23.17,70.76 23.27,70.65
TP_G4: length 1.4
  TOP w0.089: ST21.1 25.02,66.28 v1(25.1,66.2)
  BOTTOM w0.089: v1(25.1,66.2) 25.04,66.2 U1.G4
TP_GPG2: length 16.1
  TOP w0.102: HT99.1 123.22,71.7 v1(123.57,72.05)
  IN1 w0.127: v1(123.57,72.05) 123.26,72.05 122.84,71.64 118.32,71.64 115.2,74.76 112.18,74.76 v1(111.53,75.4)
  BOTTOM w0.102: v1(111.53,75.4) 111.78,75.15 U10.100
TP_H61: length 2.9
  TOP w0.089: HT3.1 23.55,28.95 23.85,28.95 v1(25.07,30.17)
  BOTTOM w0.089: U1.H61 24.76,30.48 v1(25.07,30.17)
TP_H62: length 4.7
  TOP w0.089: HT4.1 26.06,27.89 25.44,27.26 v1(25.43,27.26)
  BOTTOM w0.089: v1(25.43,27.26) 25.02,27.67 25.02,29.5 U1.H62
TP_H63: length 9
  TOP w0.089: v1(25.9,26.83) 25.9,26.34 27.05,25.19 27.05,23.18
  TOP w0.102: 27.05,23.18 27.05,22.45 HT6.1
  BOTTOM w0.089: U1.H63 24.7,27.35 25.21,26.83 v1(25.9,26.83)
TP_J61: length 5.6
  BOTTOM w0.089: HT8.1 25.55,25.9 26.3,26.64 26.3,27.85 26.01,28.14 26.01,28.8 25.91,28.9 25.91,29.51 25.78,29.64 25.78,30.19 U1.J61
TP_K2: length 4.2
  BOTTOM w0.089: 25.27,70.65 25.32,70.61 25.32,69.4 25.5,69.22 25.5,68.59 25.95,68.14 25.95,67.44 U1.K2
  BOTTOM w0.102: 25.27,70.65 ST16.1
TP_K4: length 5.6
  TOP w0.089: ST18.1 26.57,68.95 v1(26.17,69.36)
  BOTTOM w0.089: v1(26.17,69.36) 26.17,69.3 26.7,68.77 26.7,68.1 26.7,68.09 26.7,66.47 26.2,65.96 U1.K4
TP_K18: length 2.1
  TOP w0.089: v1(27.18,57.94) 26.76,57.52 PT6.1
  BOTTOM w0.089: v1(27.18,57.94) 26.79,57.94 26.68,58.06 U1.K18
TP_K59: length 1.3
  TOP w0.089: HT5.1 25.84,32.17 v1(25.86,32.2)
  BOTTOM w0.089: v1(25.86,32.2) 26.16,31.91 U1.K59
TP_K60: length 1.6
  TOP w0.089: HT7.1 27.27,30.78 v1(26.57,31.47)
  BOTTOM w0.089: U1.K60 26.5,31.47 v1(26.57,31.47)
TP_L1: length 8.2
  BOTTOM w0.089: 26.84,69.64 26.85,69.63 26.85,68.87 26.88,68.84 26.88,67.91 U1.L1
  BOTTOM w0.102: T10.1 25.61,75.22 25.61,71.35 26.6,70.36 26.6,70.25 26.84,70.01 26.84,69.64
TP_L5: length 1.7
  TOP w0.089: v1(26.39,64.73) 26.39,64.75 25.74,65.4 ST14.1
  BOTTOM w0.089: U1.L5 26.83,65.17 v1(26.39,64.73)
TP_L11: length 4.7
  TOP w0.089: v1(27.23,60.8) 27.66,60.37 27.66,60.3 27.8,60.16 29.48,60.16 30.2,60.88 AT9.1
  BOTTOM w0.089: v1(27.23,60.8) 26.77,61.26 26.77,61.28 U1.L11
TP_M20: length 1.8
  TOP w0.089: v1(28.36,57.24) 28.5,57.37 PT7.1
  BOTTOM w0.102: U1.M20 27.75,56.63 v1(28.36,57.24)
TP_N7: length 3.6
  TOP w0.089: ST15.1 27.74,65.88 27.74,64 v1(28.22,63.52)
  BOTTOM w0.089: v1(28.22,63.52) 27.87,63.87 U1.N7
TP_SMCLK2: length 3.6
  TOP w0.102: HT96.1 155.3,70.35 v1(155.3,71.09)
  BOTTOM w0.102: U20.2 154.52,70.31 v1(155.3,71.09)
