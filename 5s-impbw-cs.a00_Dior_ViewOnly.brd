# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N20072666: length 6.8
  TOP w0.254: PR70.2 PR72.1 139.47,36.31 139.28,36.12 PC53.1 ; PQ10.2 139.5,37.13 138.72,36.35 PC53.1 ; v2(136.68,34.36) 137.54,34.36 138,34.82 138,35.91 138.21,36.12 PC53.1
N20635566: length 10.7
  TOP w0.102: U12.2 74.54,84.5 74.75,84.29 75.65,84.29 76.34,84.98 77.13,84.98 C86.1 77.88,84.23 Q2.3 77.88,82.59 76.93,81.64 Q2.1 76.93,79.81 77.24,79.49 v2(77.24,78.86)
N20635568: length 15.4
  TOP w0.102: Q2.2 78.83,79.94 79.25,79.52 v2(79.25,78.96) 78.65,78.36 76.97,78.36 76.28,79.05 76.28,81.88 76.72,82.33 C86.2 76.14,83.91 74.25,83.91 73.89,84.26 U12.3
N20750391: length 2.9
  TOP w0.102: Q12.1 110.19,70.14 v2(110.01,69.96) 110.01,69.38 R244.2
N20750957: length 2.7
  TOP w0.102: CR6.1 121.17,76.63 R240.2 v2(121.17,74.71)
N20750963: length 8.1
  TOP w0.102: Q13.3 117.14,83.1 118.07,84.03 R245.2 117.43,85.12 117.43,87.76 118.04,88.38 118.67,88.38 v2(119.38,89.1)
N20750967: length 3
  TOP w0.102: R246.1 123.44,84.87 CR9.2 123.44,86.32 123.83,86.71 v2(123.83,87.11)
N20750973: length 2.7
  TOP w0.102: v2(116.86,87.04) CR7.2 116.86,85.23 117.18,84.9 R245.1
N20751540: length 2.8
  TOP w0.102: v2(118.18,78.57) CR5.1 118.18,76.55 118.33,76.41 R239.2
N21452890: length 26
  TOP w0.254: v1(32.09,77.25) 32.46,77.61 PR242.2 PR243.2 ; PC24.1 37.05,58.59 36.65,58.99 v1(36.65,59.14)
  IN1 w0.203: v1(36.65,59.14) 33.8,59.14 33.04,59.9 32.71,60.23 32.71,62.45 32.58,62.59 32.58,65.51 32.08,66.01 32.08,71.42 32.39,71.72 32.39,76.73 32.09,77.02 v1(32.09,77.25)
  BOTTOM w0.254: U1.AH14 36.56,59.14 v1(36.65,59.14)
N21453299: length 35.5
  IN3 w0.762: v3(15.89,61.28) 15.55,61.28 15.06,61.76 15.06,62.97 15.82,63.72 15.82,66.07 14.84,67.05 12.68,67.05 11.69,68.04 11.69,70.53 13.64,72.48 14.86,72.48 15.69,73.31 15.69,78.51 v3(16.26,79.09)
  BOTTOM w0.254: PC15.1 17.52,60.72 17.87,61.07 20.74,61.07 20.78,61.11 U1.B11
  BOTTOM w0.762: v3(16.26,79.09) 16.26,78.29 16.72,77.84 PC13.1 17.6,78.86 17.93,79.19 PC14.1 17.45,79.95 v2(16.33,81.07)
N21464486: length 5.8
  BOTTOM w0.102: PR52.2 66.43,89.17 v2(66.63,88.97) ; PR52.2 65.2,88.86 PQ5.6 64.25,88.47 63.68,87.9 PQ6.2 ; PR52.2 65.16,89.51 PQ5.5
N21464502: length 21.4
  TOP w0.102: v2(54.54,88.69) 55.3,88.69 v1(55.39,88.77)
  IN2 w0.102: v1(61.38,88.79) 60.74,89.43 56.04,89.43 v1(55.39,88.77)
  BOTTOM w0.102: v1(61.38,88.79) 61.38,89.88 PR50.2 61.47,90.31 61.62,90.16 PQ5.3 ; PQ1.1 54.78,84.18 54.41,84.55 PC42.1 52.44,85.27 52.44,86.49 52.86,86.91 54.38,86.91 54.64,87.16 56.11,87.16 56.36,87.42 56.36,87.8 v1(55.39,88.77)
N21464524: length 24.1
  IN1 w0.102: v1(64.39,79.13) 63.92,78.66 55.55,78.66 v1(55.37,78.83)
  BOTTOM w0.102: v1(64.39,79.13) 64.72,79.46 64.72,82.39 63.03,84.08 PQ6.6 ; PR49.2 55.81,84.23 55.81,82.29 56.55,81.54 56.55,80.49 55.37,79.32 v1(55.37,78.83) 55.86,78.35 v2(55.86,78.27)
N21593691: length 4.6
  TOP w0.102: v2(129.57,82.72) 129.03,83.25 129.03,84.09 128.68,84.45 R237.2 127.37,83.59 Q8.3
N21593695: length 3.8
  TOP w0.102: v2(125.64,87.04) 125.64,86.03 125.91,85.75 CR1.2 126.77,85.03 R237.1
N21597614: length 2.9
  BOTTOM w0.102: U10.29 97.44,86.93 v2(97.26,87.11) 96.56,87.11 R181.1
N22586138: length 4.7
  TOP w0.102: v2(139.78,56.13) 140.08,56.13 PR95.1
  TOP w0.254: PR95.1 140.59,55.2 140.59,54.3 v1(140.72,54.17)
  BOTTOM w0.254: PU3.13 140.29,52.87 140.13,53.03 140.13,53.59 v1(140.72,54.17)
N22586155: length 3.2
  TOP w0.102: v1(139.67,53.77) 139.67,53.81 138.99,54.49 v2(138.99,54.53)
  BOTTOM w0.254: PR96.1 139.99,54.09 v1(139.67,53.77) 139.67,53.01 139.79,52.9 PU3.12
N22635369: length 12
  TOP w0.102: R187.1 95,81.6 v2(95.05,81.55) 95.45,81.96 98.45,81.96 99.52,80.89 100.36,80.89 100.71,80.54 101.34,80.54 v1(101.64,80.23)
  BOTTOM w0.102: U10.16 100.43,81.73 101.64,80.52 v1(101.64,80.23)
N22755977: length 5.3
  TOP w0.102: PR69.2 135.96,40.7 PC52.1 136.71,40.7 136.83,40.58 PQ9.5 ; PR69.2 135.92,41.78 PR71.1 ; PR69.2 135.4,41.81 135.23,41.98 v2(135.23,42.49)
N23444734: length 6.9
  TOP w0.102: R238.2 113.56,84.53 113.68,84.41 113.68,82.93 113.55,82.8 Q9.3 113.01,82.07 112.5,81.55 110.85,81.55 110.64,81.35 v2(110.64,80.8)
N23444738: length 1.3
  TOP w0.102: CR2.2 112.21,85.11 112.1,85 R238.1
N23444978: length 3.7
  TOP w0.102: v2(122.54,84.42) 121.92,84.42 121.87,84.47 R242.2 121.25,82.9 121.05,82.7 Q11.3
N23444995: length 9.1
  TOP w0.102: CR4.2 120.16,85.18 120.36,84.98 R242.1 120.36,83.88 119.91,83.43 119.91,82.03 120.25,81.7 121.72,81.7 122.12,81.3 122.12,78.94 v2(121.97,78.78)
N23445232: length 5.2
  TOP w0.102: R241.2 114.81,73.21 115.08,72.94 115.34,72.94 115.51,73.11 Q10.3 v2(117.73,73.75)
N23445249: length 3.2
  TOP w0.102: CR3.2 113,76.15 v2(113.35,75.8) 113.35,75.19 113.31,75.15 R241.1
N25225282:
  vias: v2(17.73,47.72)
N25313378: length 3.7
  TOP w0.102: Q30.3 170.89,67.89 170.69,67.68 170.68,67.68 170.58,67.58 170.18,67.58 170,67.4 R318.2 v2(168.81,66.53)
N26708130: length 7.6
  TOP w0.102: Q27.6 172.43,71.51 R313.2 172.35,71.96 172.09,72.23 172.09,72.71 171.53,73.27 170.36,73.27 170.18,73.45 170.18,74.16 v2(171.2,75.18)
N27218464: length 3
  BOTTOM w0.102: v2(42.95,18.58) 42.7,18.58 42.62,18.51 HR6.2 41.37,18.51 41.03,18.85 HQ1.1
N27260469: length 2.6
  TOP w0.102: GR10.2 59.69,6.06 59.78,5.97 v2(60.33,5.97) 60.34,5.96 GR12.1
N27578047: length 3.8
  TOP w0.102: v2(126.06,84.45) 125.5,84.45 125.47,84.47 R246.2 124.73,83.06 124.37,82.7 Q14.3
N27745052: length 1.6
  TOP w0.508: C144.1 169.71,38.71 ; C144.1 170.22,38.18 ; C144.1 169.71,37.64
  vias: v2(169.44,39.49)
N27745067: length 1.4
  TOP w0.381: R296.1 169.61,12.8 ; R298.1 170.65,12.95
  vias: v2(169.93,12.18)
N28007042: length 2.5
  TOP w0.508: R47.2 49.67,20.36 49.7,20.34 C43.2 49.05,19.8 v2(48.57,19.32)
N28007175: length 2.5
  TOP w0.508: v2(73.53,16.58) 73.96,16.58 74.21,16.83 C42.2 74.75,16.71 R46.2
N28055402: length 2.8
  TOP w0.508: v2(52.22,20.92) 52.45,20.7 C46.1 53.68,21.04 R63.2
N29535167: length 17.1
  TOP w0.089: 46.51,69.62 46.25,69.37 46.25,68.65 45.1,67.49 44.79,67.49 41.78,64.48 41.35,64.48 41,64.13 41,63.95 40.64,63.59 37.86,63.59 v1(36.96,64.5)
  TOP w0.102: v2(45.57,72.35) 45.87,72.35 45.96,72.26 46.21,72.26 PR26.2 46.72,71.75 46.72,69.84 46.51,69.62
  BOTTOM w0.089: v1(36.96,64.5) 36.96,64.47 37.01,64.42 37.01,64.35 37.25,64.11 U1.AL7
N29710752: length 4.5
  TOP w0.102: v1(105.34,19.08) 105.34,19.89 105.13,20.1 v2(104.6,20.1) 103.73,20.1 R279.1
  BOTTOM w0.102: CONSATA.54 v1(105.34,19.08)
N29714116: length 4.6
  TOP w0.102: v2(178.92,55.24) 178.92,55.95 v1(178.91,55.95) 178.57,56.29 R60476.2 R307.2
  BOTTOM w0.102: v1(178.91,55.95) 178.91,55.64 179.32,55.24 179.79,55.24 179.91,55.35 CONWIFI.55
N29714833: length 9
  BOTTOM w0.102: v2(177.04,73.75) 176.61,73.32 176.61,72.64 176.47,72.5 R310.1 175.94,72.49 R311.1 174.19,71.71 173.93,71.44 Q26.3 Q25.3
N29714844: length 1.4
  BOTTOM w0.254: 179.25,69.89 180.54,69.89 v2(180.62,69.97)
N29714858: length 7.2
  BOTTOM w0.102: C147.1 175.94,70.45 175.94,70.46 R311.2 176.9,70.87 177.23,71.21 Q24.1 177.83,72.25 178.76,71.32 179.91,71.32 v2(180.54,71.95)
N29748668: length 10.7
  TOP w0.102: V1C21.1 159.24,33.85 R129.2 158.51,33.71 158.51,33 v2(158.01,32.5) 158.01,31.72 158.45,31.28 159.51,31.28 159.87,30.93 159.87,28.79 160.3,28.36 160.3,27.86 160.89,27.27 U6.12
N29748720: length 6.4
  TOP w0.102: U6.34 159.69,18.69 159.26,18.25 159.26,17.07 C68.1 159.11,16.34 159.11,15.21 R130.2 158.83,14.77 158.68,14.62 v2(158.17,14.62)
N29865327: length 6.2
  TOP w0.102: U21.7 178.84,50.9 179.05,50.7 179.21,50.7 179.78,50.13 C200.1 180.75,49.67 182.21,49.67 R376.2 183.09,48.79 183.15,48.79 v2(183.62,48.33)
N29865353: length 6.1
  TOP w0.102: v2(182.53,53.56) 182.53,53.28 182.06,52.81 181.9,52.81 181.54,52.44 180.74,52.44 R377.1 179.89,52.56 179.89,51.96 179.68,51.76 179.2,51.76 179.05,51.9 179.05,52.13 178.78,52.4 U21.10
N30153364: length 20.7
  TOP w0.089: 17.27,62.88 v1(17.41,62.88)
  TOP w0.102: 17.27,62.88 16.62,62.88 v2(16.59,62.91) ; v1(11.85,71.76) 12.54,71.76 13.95,73.17 13.95,73.7 14.02,73.78 R60365.1
  IN2 w0.102: v1(11.85,71.76) 11.41,71.32 11.41,68.66 16.92,63.14 17.15,63.14 v1(17.41,62.88)
  BOTTOM w0.089: U1.A8 19.99,63.27 19.75,63.5 19,63.5
  BOTTOM w0.102: v1(17.41,62.88) 17.85,62.88 18.48,63.5 19,63.5
N30155734: length 19.2
  TOP w0.089: v1(29.23,64.07) 29.63,64.47 29.63,65.53 29.21,65.96 29.21,66.32 29.65,66.76 29.65,68.95 28.12,70.48 27.81,70.48 27.61,70.68
  TOP w0.102: SR85.1 23.77,77.34 23.94,77.17 23.94,76.64 v2(24.46,76.12) 24.64,76.29 25,76.29 25.12,76.42 26.89,76.42 27.46,75.85 27.46,74.54 27.51,74.49 27.51,74.18 27.57,74.11 27.57,72.68 27.55,72.66 27.55,70.74 27.61,70.68
  BOTTOM w0.089: U1.R7 29.03,63.87 v1(29.23,64.07)
N30168885: length 10.2
  TOP w0.102: T9207.1 152.41,65.45 R9204.2 154,65.45 154.31,65.14 C9200.1 153.77,64.66 153.7,64.58 153.7,64.27 153.96,64.01 D9200.1 154.46,63.37 154.59,63.24 154.59,61.46 154.75,61.3 Q9200.5 156.2,61.3 156.36,61.13 156.36,60.82 156.19,60.65 Q9200.6
N30168926: length 3.6
  TOP w0.102: Q9200.2 157.06,61.3 156.87,61.49 156.87,62.17 157.22,62.53 v2(157.22,63.23) 157.22,63.78 157.24,63.8 SR9206.1
N30168991: length 8.6
  TOP w0.254: R60466.2 139.14,79.19 139.4,78.94 139.4,78.63 139.87,78.16 R60465.2 139.6,77.77 139.6,77.52 R9203.1 138.91,76.83 R60469.1 ; R60466.2 137.47,79.19 v2(136.81,78.53) ; R60466.2 R60467.2 R60468.2
N30187936: length 2.9
  TOP w0.508: v2(53.04,14.44) 54.02,14.44 C45.1 55.01,14.89 55.09,14.8 R62.2
N30286706: length 5.1
  BOTTOM w0.102: U20.10 151.85,74.31 PC197.1 150.41,74.9 149.71,74.9 149.18,75.43 v2(148.52,75.43)
N30286716: length 7.7
  BOTTOM w0.102: U20.8 150.69,73.31 CKC5.1 148.49,71.11 X3.1 v2(147.43,69.66)
N30286731: length 4.5
  TOP w0.102: R370.2 R371.2 158.17,69.18 v1(158.47,69.48) 158.78,69.79 v2(158.78,70.25)
  BOTTOM w0.102: U20.39 158.93,69.03 v1(158.47,69.48)
N30286848: length 13.3
  BOTTOM w0.102: v2(145.16,75.91) 145.77,76.52 145.77,76.83 146.89,77.94 149.15,77.94 149.48,78.27 149.48,79.44 149.84,79.8 151.18,79.8 152.01,78.98 D24.2 153.61,78.98 154.01,79.38 R60369.2 R60368.2
N30289244: length 2.6
  TOP w0.254: CA11.1 v2(161.79,51.86)
  TOP w0.406: UA3.14 161.8,53.97 161.79,53.97 CA11.1
N30327416: length 27
  TOP w0.102: F3J1.10 133.54,83.73 133.43,83.84 133.15,83.84 132.82,83.51 132.46,83.51 132.18,83.22 132.18,82.3 132.77,81.71 132.77,77.56 133.24,77.09 135.17,77.09 136.02,77.94 136.02,79.01 137.01,80 137.69,80 138.43,80.74 138.43,82 F3R13.2 139.86,83.43 143.18,83.43 v2(144.32,82.29) 145.52,81.09 Q9202.1
N30542822: length 158.3
  TOP w0.102: v1(160.22,83.66) 160.23,83.65 U17.8 161.24,83.65 161.6,84 161.6,84.98 R414.2 161.77,85.64 161.77,87.67 v2(161.98,87.88)
  IN1 w0.102: v1(153.85,80.46) 153.85,81.01 156.92,84.08 159.81,84.08 v1(160.22,83.66)
  IN2 w0.102: v1(24.69,79.99) 27.25,82.54 31.93,82.54 32.08,82.7 34.59,82.7 35.86,81.42 38.49,81.42 39.98,82.91 41.03,82.91 42.13,81.81 43.67,81.81 44.77,82.92 48.58,82.92 48.92,83.26 55.37,83.26 55.78,82.86 62.14,82.86 62.91,83.63 66.52,83.63 67.54,84.65 83.35,84.65 84.11,83.89 85.27,83.89 85.8,83.35 87.87,83.35 88.44,83.93 93.28,83.93 94.03,84.68 96,84.68 96.7,83.97 105.68,83.97 106.75,85.04 112.62,85.04 114.69,82.97 120.24,82.97 120.69,83.42 130.28,83.42 130.56,83.7 132.88,83.7 133.15,83.43 137.25,83.43 137.79,83.96 139.78,83.96 140.52,83.23 142.84,83.23 145.48,80.59 153.72,80.59 v1(153.85,80.46)
  BOTTOM w0.102: v1(24.69,79.99) 24.69,79.97 24.5,79.78 24.5,77.95 24.31,77.76 24.31,77.28 22.98,75.95 R415.1
N30852551: length 65.4
  TOP w0.102: v1(29.61,81.03) 29.43,80.86 29.43,79.05 30.68,77.8 30.68,76.2 30.53,76.05 30.53,75.5 30.97,75.06 v1(30.97,75.05) ; v2(8.28,81.22) 8.68,81.62 D4.1 8.68,83.56 8.51,83.74 7.72,83.74 6.86,84.6 6.25,84.6 v1(6.17,84.68)
  IN1 w0.102: v1(6.17,84.68) 5.67,85.18 5.67,85.77 5.41,86.02 5.06,86.02 4.23,85.19 4.23,79.27 4,79.04 4,75.75 5.79,73.96 7.02,73.96 7.64,74.58 10.21,74.58 10.68,75.05 11.25,75.05 12.13,75.93 18.48,75.93 19.74,77.19 19.74,78.67 21.43,80.35 23.97,80.35 24.56,80.94 25.53,80.94 26.11,80.36 28.93,80.36 v1(29.61,81.03)
  BOTTOM w0.089: 30.07,68.93 30.07,68.24 30.27,68.05 30.27,67.45 30.32,67.4 30.32,66.29 30.02,65.99 U1.U4
  BOTTOM w0.102: v1(30.97,75.05) 30.75,74.83 30.75,73.62 30.43,73.3 30.43,71.56 30.07,71.21 30.07,68.93
N31162111: length 5.1
  TOP w0.406: Q30.6 169.59,69.61 168.84,68.85 167.87,68.85 167.67,69.05 v2(167.24,69.05) 167.11,68.93 167.11,67.92 R432.2
N31162129: length 3
  TOP w0.102: Q29.3 173.81,64.48 173.59,64.25 v2(173.59,63.8) 173.01,63.22 173.01,63.14 R433.2
N31194135: length 8.4
  TOP w0.102: R436.1 165.24,66.28 165.26,66.26 C400.1 165.26,64.57 165.16,64.47 PQ34.2 164.6,65.26 164.03,65.83 164.03,66.21 163.87,66.37 162.7,66.37 162.57,66.24 PD8.1 161.79,65.89 v2(161.24,65.35)
N31763353: length 12.9
  TOP w0.102: v1(2.24,81.25) 2.36,81.25 3.23,82.11 3.23,83.77 3.23,84.34 v2(3.24,84.35) 5.14,86.25 5.41,86.25 5.97,86.81 7.29,86.81 8.09,86.01 R60474.1 R60475.1
  BOTTOM w0.102: v1(2.24,81.25) 2.41,81.25 2.91,81.74 CON10.46
N31837906: length 6.6
  BOTTOM w0.102: PR236.2 PR239.2 107.06,36.87 v2(106.63,37.3) 106.05,36.72 PR241.1 105.68,36.35 105.23,36.8 104.37,36.8 103.85,37.32 PQ35.3
N43909756: length 14.2
  BOTTOM w0.102: CON7.4 15.26,63.62 15.47,63.42 15.47,63.01 14.91,62.45 D13.2 14.91,60.95 15.29,60.57 15.29,60.06 15.04,59.81 7.34,59.81 v2(6.68,59.15)
N189359983: length 14.7
  TOP w0.508: R180.2 v2(115.03,86.72) 114.26,86.72 114.2,86.78 v1(113.49,86.78)
  IN2 w0.508: v1(118.81,84.26) 115.15,84.26 113.49,85.92 v1(113.49,86.78)
  BOTTOM w0.178: C74.1 116.58,85.02 116.09,84.53 U10.74
  BOTTOM w0.457: C74.1 116.85,84.41 C73.1
  BOTTOM w0.508: C73.1 118.61,84.05 v1(118.81,84.26)
N189359986: length 8
  TOP w0.102: v1(100.08,80.25) 99.86,80.03 R217.1 98.64,80.71 98.17,80.71 98.12,80.66 C79.1 97.4,79.89 v2(96.95,79.44)
  BOTTOM w0.102: v1(100.08,80.25) 99.97,80.13 U10.12 97.64,80.13 97.47,79.96 C78.1
N189360895: length 7
  TOP w0.102: v2(98.43,81.22) 98.96,80.69 100.26,80.69 100.84,80.1 v1(101,80.1) 101.01,80.09 D6.2
  BOTTOM w0.102: v1(101,80.1) 101,80.76 100.42,81.33 U10.15
N189360909: length 8.6
  BOTTOM w0.102: v2(93.4,82.41) 92.99,82.82 92.99,83.87 93.59,84.47 93.85,84.47 94.09,84.7 D7.2 94.59,84.97 94.74,85.12 96.54,85.12 97.23,84.42 97.91,84.42 98.02,84.53 U10.23
N251857507: length 6.1
  TOP w0.102: R192.1 94.11,82.45 v1(94.87,83.21)
  BOTTOM w0.102: v1(94.87,83.21) 95.19,83.21 95.61,83.63 96.43,83.63 96.59,83.48 97.03,83.48 v2(97.23,83.28) 97.23,83.08 98.17,82.13 U10.17
N3060610255: length 11.6
  TOP w0.102: U6.56 166.8,22.72 v1(166.83,22.75) ; HT94.1 174.14,21.56 v1(173.99,21.4)
  IN3 w0.102: v1(173.99,21.4) 172.29,19.7 170.9,19.7 170.13,20.48 168.88,20.48 167.88,21.48 166.98,21.48 166.57,21.89 166.57,22.5 v1(166.83,22.75)
N3060610256: length 13.9
  TOP w0.102: v1(173.99,20.77) 174.14,20.92 HT93.1 ; U6.57 v1(165.3,23.12)
  IN3 w0.102: v1(165.3,23.12) 165.3,21.89 165.99,21.2 167.87,21.2 168.8,20.27 170.04,20.27 170.82,19.5 172.72,19.5 v1(173.99,20.77)

## Copper pours and planes (outline as drawn)
+1.05VS_AUSB3PLL on BOTTOM (solid shape): 13.67,83.91 13.67,83.44 14.23,82.88 15.02,82.88 15.37,82.53 15.37,82.07 15.29,81.98 12.83,81.98 12.24,82.57 12.24,83.91 12.38,84.05 13.53,84.05
+1.05VS_AUSB3PLL on IN2 (solid shape): 19.48,57.5 19.48,56.33 19.28,56.12 18.91,56.12 17.94,57.09 17.94,57.65 18.01,57.72 19.26,57.72
+1.05VS_HSIO on BOTTOM (solid shape): 18.23,83.66 18.23,83.18 18.05,83 17.68,83 17.41,83.27 14.45,83.27 14.39,83.33 14.39,84.18 14.55,84.34 17.54,84.34
+1.05VS_VCCACLKPLL on BOTTOM (solid shape): 14.06,42.92 14.06,42.36 15.11,41.32 16.23,41.32 16.33,41.22 16.33,39.37 15.07,39.37 13.85,38.15 13.84,38.15 13.22,37.52 12.3,37.52 12.3,38.27 12.4,38.37 12.98,38.37 14.13,39.52 14.13,41.04 13.15,42.03 13.15,43.01 13.33,43.2 13.78,43.2
+1.05VS_VCCHSIO on IN1 (solid shape): 25.41,67.9 25.41,67.11 25.28,66.97 24.31,66.97 24.11,67.17 24.11,68.08 24.13,68.09 25.22,68.09
+3VA on BOTTOM (solid shape): 105.13,42.51 105.13,41.6 104.21,40.68 101.34,40.68 100.83,41.19 100.83,42.45 101.06,42.68 104.96,42.68
+3VA on BOTTOM (solid shape): 121.02,57.62 121.02,55.89 121.98,54.93 123.56,54.93 123.77,54.73 123.77,50.65 122.79,49.68 119.93,49.68 119.8,49.81 119.8,50.59 115.02,55.37 115.02,56.15 115.07,56.21 116.01,56.21 117.27,57.46 119.06,57.46 119.29,57.69 120.96,57.69
+3VA on IN2 (solid shape): 105.91,42.28 105.91,40.57 105.47,40.12 104.08,40.12 103.38,40.82 103.38,42.33 103.75,42.71 105.49,42.71
+3VA on IN2 (solid shape): 119.01,55.95 119.01,55.08 118.83,54.9 116.87,54.9 116.7,55.08 116.7,55.98 117.02,56.29 118.67,56.29
+3VA on IN2 (solid shape): outline of 1707 points within 147.83,65.65 163.82,77.74
+3VA_BST1_D on BOTTOM (solid shape): 118.65,65.95 118.65,62.88 117.88,62.88 117.88,65.8 118.19,66.11 118.49,66.11
+3VA_BST_D on BOTTOM (solid shape): 120.47,65.42 120.47,65.24 120.69,65.02 121.06,65.02 121.18,64.9 121.18,64.53 121.44,64.26 121.44,63.52 121.61,63.34 122.34,63.34 122.34,63.13 121.38,63.13 120.43,64.08 119.83,64.08 119.72,64.19 119.72,65.38 119.81,65.47 120.42,65.47
+3VA_IN on BOTTOM (solid shape): 115.91,43.14 115.85,43.08 115.84,43.08 115.26,42.51 115.26,41.06 115.1,40.89 112.22,40.89 112.22,44.15 112.29,44.22 113.56,44.22 113.57,44.23 115.91,44.23
+3VA_PHASE_R on BOTTOM (solid shape): 121.25,62.88 122.3,62.88 122.34,62.84 122.34,62.71 119.18,62.71 119.1,62.79 119.1,63.67 119.12,63.69 120.44,63.69
+3VA_PHASE_R on BOTTOM (solid shape): 118.9,50.34 118.9,48.33 120.15,47.08 120.15,44.8 116.21,44.8 115.9,44.48 115.38,44.48 115.21,44.65 114.36,44.65 114.33,44.69 114.33,47.19 113.72,47.8 113.72,52.63 113.88,52.78 116.46,52.78
+3VA_R1_HG_D on BOTTOM (solid shape): 113.94,47.07 113.94,46.42 114.05,46.32 114.05,44.47 111.6,44.47 111.57,44.49 111.57,45.31 111.61,45.35 113.07,45.35 113.24,45.53 113.24,47.02 113.35,47.14 113.88,47.14
+3VA_R1_LG_D on BOTTOM (solid shape): 122.61,47.07 122.61,46.29 122.83,46.06 122.83,45.34 122.75,45.26 121.53,45.26 121.52,45.27 121.52,46.29 121.21,46.61 120.44,46.61 120.41,46.63 120.41,47.08 120.5,47.17 122.51,47.17
+3VA_SN_C on BOTTOM (solid shape): 119.55,44.18 119.85,44.18 119.91,44.11 119.91,43.3 119.84,43.23 116.69,43.23 116.64,43.27 116.64,44.14 116.68,44.18 119.55,44.18
+5V on TOP (solid shape): 172.89,39.23 172.89,37.81 171.58,37.81 171.43,37.96 171.43,39.17 171.59,39.34 172.78,39.34
+5V on TOP (solid shape): 179.58,65.07 179.58,63.85 179.48,63.75 178.13,63.75 177.9,63.97 177.9,64.99 178.06,65.14 179.5,65.14
+5V on BOTTOM (solid shape): 132.69,59.88 132.69,57.22 132.22,56.74 131.66,56.74 130.45,57.96 130.45,60.14 130.63,60.32 131.02,60.32 131.32,60.62 131.95,60.62
+5V on BOTTOM (solid shape): 16.77,68.22 16.77,67.17 16.89,67.05 17.43,67.05 17.63,66.84 17.63,65.78 17.53,65.68 17.1,65.68 16.84,65.93 16,65.93 14.96,66.97 14.96,66.97 12.98,66.97 12.98,67.73 13.33,68.08 15.69,68.08 15.9,68.29 16.69,68.29
+5V on IN1 (solid shape): 159.66,61.99 159.66,60.62 159.23,60.19 158.85,60.19 158.75,60.29 158.75,60.67 158.4,61.02 158.4,61.89 158.52,62.01 159.64,62.01
+5V on IN1 (solid shape): 178.02,66.93 178.05,66.84 177.98,66.77 177.73,66.46 177.86,66.08 177.9,66.01 177.86,65.93 177.78,65.43 178.25,65.24 178.34,65.22 178.39,65.14 178.39,64.18 178.23,64.03 177.78,64.03 176.48,65.32 176.48,65.33 176.21,65.78 175.76,66.05 175.75,66.05 175.69,66.11 174.19,66.11 174.04,66.27 174.04,67.42 174.1,67.48 177.47,67.48
+5V on IN1 (solid shape): 165.03,63.54 165.03,63.49 165.03,62.31 161.78,62.31 161.78,63.52 162.71,63.52 162.72,63.46 162.73,63.41 162.75,63.35 162.77,63.3 162.81,63.26 162.84,63.21 162.84,63.19 162.81,63.14 162.77,63.1 162.75,63.05 162.73,62.99 162.72,62.93 162.71,62.88 162.72,62.82 162.73,62.76 162.75,62.71 162.78,62.66 162.81,62.61 162.86,62.57 162.9,62.54 162.95,62.51 163.01,62.49 163.06,62.48 163.12,62.47 163.18,62.48 163.23,62.49 163.29,62.51 163.34,62.54 163.39,62.57 163.43,62.61 163.46,62.66 163.49,62.71 163.51,62.76 163.52,62.82 163.53,62.88 163.52,62.93 163.51,62.99 163.49,63.05 163.47,63.1 163.43,63.14 163.4,63.19 163.4,63.21 163.43,63.26 163.47,63.3 163.49,63.35 163.51,63.41 163.52,63.46 163.53,63.52 163.52,63.58 163.51,63.64 163.49,63.69 163.46,63.74 163.43,63.79 163.39,63.83 163.34,63.86 163.29,63.89 163.23,63.91 163.18,63.92 163.12,63.92 163.06,63.92 163.01,63.91 162.95,63.89 162.9,63.86 162.86,63.83 162.81,63.79 162.78,63.74 162.75,63.69 162.73,63.64 162.72,63.58 162.71,63.52 161.78,63.52 161.78,65.16 161.8,65.18 165.03,65.18
+5V on IN2 (solid shape): 172.47,38.19 172.19,37.91 171.29,37.91 171.29,39.2 171.49,39.39 172.47,39.39
+5V on IN2 (solid shape): 175.8,66.54 175.8,66.13 175.45,66.13 175.2,66.09 174.95,66 174.74,65.88 174.57,65.7 174.45,65.52 174.38,65.35 174.31,65.12 174.31,64.99 174.06,64.73 173.54,64.73 173.15,65.13 173.15,65.49 173.45,65.79 173.79,65.79 174,66 174,66.31 174.36,66.67 175.68,66.67
+5V on IN2 (solid shape): outline of 252 points within 169.64,52.12 172.33,59.37
+5V on IN2 (solid shape): outline of 1385 points within 131.19,46.92 145.84,60.82
+5V on VCC (solid shape): outline of 502 points within 3.14,34.99 147.7,73.5
+5V on IN3 (solid shape): 159.49,60.98 159.49,59.98 159.11,59.6 157.93,59.6 157.9,59.62 157.85,59.65 157.8,59.67 157.74,59.68 157.68,59.68 157.63,59.68 157.57,59.67 157.52,59.65 157.47,59.62 157.44,59.6 156.66,59.6 156.63,59.62 156.58,59.65 156.53,59.67 156.48,59.68 156.08,60.08 156.08,60.44 157.94,60.44 157.94,60.39 157.95,60.33 157.97,60.28 158,60.23 158.03,60.18 158.07,60.14 158.12,60.11 158.17,60.08 158.22,60.06 158.27,60.04 158.33,60.04 158.39,60.04 158.44,60.05 158.5,60.07 158.55,60.09 158.6,60.12 158.64,60.16 158.67,60.2 158.71,60.25 158.73,60.3 158.74,60.36 158.75,60.42 158.75,60.47 158.74,60.53 158.73,60.58 158.71,60.64 158.67,60.68 158.64,60.73 158.6,60.77 158.55,60.8 158.5,60.82 158.44,60.84 158.39,60.85 158.33,60.85 158.27,60.85 158.22,60.83 158.17,60.81 158.12,60.78 158.07,60.75 158.03,60.71 158,60.66 157.97,60.61 157.95,60.56 157.94,60.5 157.94,60.44 156.08,60.44 156.08,61.76 156.24,61.92 158.55,61.92
+5V on IN3 (solid shape): outline of 94 points within 144.45,46.36 151.51,50.21
+5V_DUAL on TOP (solid shape): outline of 214 points within 128.75,57.58 133.51,63.26
+5V_DUAL on BOTTOM (solid shape): 39.73,85.56 39.73,85.18 39.24,84.69 39.24,84.4 39.09,84.26 38.39,84.26 38.13,84.52 38.13,85.67 38.15,85.69 39.59,85.69
+5V_DUAL on BOTTOM (solid shape): outline of 112 points within 6.58,73.31 10.06,78.37
+5V_DUAL on VCC (solid shape): outline of 378 points within 8.84,58.84 139.42,87.32
+5V_LCD on TOP (solid shape): 172.59,37.33 172.59,36.54 172.34,36.29 171.02,36.29 170.87,36.44 170.87,37.28 170.99,37.41 172.52,37.41
+5V_LCD on TOP (solid shape): 147.6,14.65 147.6,13.63 147.5,13.53 147.5,11.42 147.85,11.07 148.44,11.07 148.57,10.94 148.57,10.43 148.45,10.32 146.46,10.32 146.38,10.39 146.38,11.14 145.67,11.85 145.67,14.22 146.25,14.8 147.45,14.8
+5V_LCD on BOTTOM (solid shape): 147.65,14.83 147.65,13.86 147.42,13.63 146.28,13.63 145.98,13.94 145.98,14.98 146.13,15.13 147.35,15.13
+5V_LCD on BOTTOM (solid shape): 171.83,37.3 171.83,36.34 171.6,36.11 170.46,36.11 170.16,36.42 170.16,37.46 170.31,37.61 171.53,37.61
+5V_SATA on TOP (solid shape): 186.21,65.29 186.3,65.23 186.3,65.13 186.21,64.64 186.49,64.23 186.54,64.15 186.2,63.51 186.54,62.88 186.49,62.79 186.22,62.42 186.26,61.96 186.26,61.86 186.17,61.82 185.27,61.82 184,63.09 183.97,63.09 183.97,63.75 183.16,63.75 183.16,63.09 182.2,63.09 181.97,63.31 181.94,63.41 182.01,63.48 182.12,64.21 181.49,63.83 181.46,63.75 181.38,63.72 180.8,63.72 180.67,63.85 180.67,65.04 180.87,65.24 182.63,65.24 182.86,65.02 183.94,65.02 184.21,65.29 185.84,65.29 185.84,65.29
+5VA on BOTTOM (solid shape): 124.28,66.92 124.28,66.04 123.55,65.31 123.55,64.56 123.49,64.5 123.49,63.89 123.29,63.89 123.29,66.93 124.28,66.93
+5VA on BOTTOM (solid shape): 59.54,9.75 59.54,9.47 59.39,9.31 59.08,9.31 58.73,8.96 58.17,8.96 57.99,8.78 57.99,8.17 57.89,8.07 56.87,8.07 56.75,7.94 56.19,7.94 56.03,8.09 56.03,8.6 56.47,9.03 57.52,9.03 57.84,9.35 57.84,9.77 57.94,9.87 59.41,9.87
+5VSB on TOP (solid shape): 106.17,63.85 106.4,63.85 106.41,63.85 106.54,63.85 106.63,63.76 106.63,63.15 106.41,62.92 106.1,62.92 106.02,63.01 106.02,63.1 105.56,63.56 105.25,63.56 105,63.81 105,64.03 105.13,64.16 105.86,64.16
+5VSB on TOP (solid shape): 130.23,59.03 130.23,56.87 130.2,56.85 130.16,56.85 129.71,56.52 130.01,56.05 130.03,56.05 130.29,55.78 130.29,55.27 129.9,54.88 128.88,54.88 128.42,55.34 128.42,58.87 128.68,59.12 130.14,59.12
+5VSB on BOTTOM (solid shape): outline of 167 points within 128.04,49.7 134.79,59.57
+5VSB_BST1_D on BOTTOM (solid shape): 128.42,65.76 128.42,62.98 128.23,62.79 127.4,62.79 127.4,65.38 127.71,65.7 127.71,65.88 127.84,66.01 128.17,66.01
+5VSB_BST_D on BOTTOM (solid shape): 126.43,65.31 126.43,64.05 126.36,63.97 126.15,63.97 125.32,63.15 124.45,63.15 124.45,63.25 124.49,63.29 125.12,63.29 125.42,63.58 125.42,64.14 125.02,64.53 125.02,64.84 125.55,65.37 126.37,65.37
+5VSB_IN on BOTTOM (solid shape): outline of 156 points within 125.07,39.42 128.98,44.29
+5VSB_PHASE_R on BOTTOM (solid shape): 127.14,63.44 127.14,62.73 127.02,62.61 125.72,62.61 125.58,62.76 124.46,62.76 124.44,62.78 124.44,62.9 124.47,62.94 125.43,62.94 126.05,63.56 126.24,63.56 126.25,63.56 127.02,63.56
+5VSB_PHASE_R on BOTTOM (solid shape): 130.07,50.93 130.07,50.53 130.07,50.53 130.07,50.07 133.02,47.12 133.02,44.95 131.98,44.95 131.78,45.15 129.27,45.15 128.75,44.63 128.75,44.59 128.12,44.59 128.01,44.7 127.22,44.7 127.19,44.74 127.19,47.47 125.6,49.06 125.6,52.67 128.33,52.67
+5VSB_R1_HG_D on BOTTOM (solid shape): 126.91,47.19 126.91,44.59 124.66,44.59 124.54,44.7 124.54,45.38 124.61,45.46 126.13,45.46 126.29,45.62 126.29,47.1 126.45,47.26 126.84,47.26
+5VSB_R1_LG_D on BOTTOM (solid shape): 135.24,46.85 135.24,46.35 135.49,46.1 135.83,46.1 135.93,46 135.93,45.17 135.88,45.12 134.91,45.12 134.65,45.38 134.65,46.2 134.06,46.8 133.28,46.8 133.28,47.19 133.33,47.24 134.85,47.24
+5VSB_SN_C on BOTTOM (solid shape): 132.54,44 132.54,43.44 132.41,43.31 131.43,43.31 131.15,43.03 129.54,43.03 129.48,43.09 129.48,44.03 129.5,44.05 132.49,44.05
+5VSB_VIN_C_R on BOTTOM (solid shape): 123.07,67.05 123.07,63.9 122.9,63.9 122.9,64.87 122.07,65.7 122.07,66.87 121.95,66.99 121.31,66.99 121.27,67.03 121.27,67.53 121.31,67.56 122.56,67.56
+12V_+19V on TOP (solid shape): 42.81,89.04 42.81,88.58 42.65,88.42 40.46,88.42 40.36,88.51 40.36,88.89 40.6,89.13 42.72,89.13
+12V_+19V on BOTTOM (solid shape): 44.59,89.35 44.59,88.62 44.38,88.41 41.28,88.41 41.05,88.64 41.05,88.94 41.2,89.1 41.53,89.1 41.73,89.29 41.73,89.68 41.85,89.8 44.14,89.8
+12V_+19V on BOTTOM (solid shape): 11.13,87.93 11.13,87.22 10.81,86.89 9.59,86.89 9.59,86.9 9.51,86.9 9.28,87.12 7.23,87.12 7.21,87.14 7.21,87.36 9.22,87.36 9.27,87.41 9.27,87.58 9.22,87.63 7.21,87.63 7.21,87.85 7.23,87.87 9.34,87.87 9.57,88.11 10.95,88.11
+19V_BL_F on TOP (solid shape): 165.66,14.57 165.66,14.22 165.94,13.94 167.97,13.94 168.02,13.89 168.02,13.33 167.87,13.17 167.36,13.17 167.18,13 167.18,11.5 166.93,11.24 166.93,10.55 167.24,10.25 167.24,9.34 166.96,9.06 165.79,9.06 165.38,9.47 165.38,11.8 164.54,12.64 164.54,14.57 164.67,14.7 165.53,14.7
+19V_BL_F on BOTTOM (solid shape): 167.36,10.84 167.36,8.91 167.34,8.88 167.16,8.88 167.13,8.91 167.13,9.77 167.11,9.8 166.88,9.8 166.85,9.77 166.85,8.91 166.83,8.88 166.68,8.88 166.63,8.93 166.63,9.77 166.6,9.8 166.42,9.8 166.37,9.75 166.37,8.93 166.32,8.88 166.19,8.88 166.14,8.93 166.14,9.75 166.09,9.8 165.91,9.8 165.86,9.75 165.86,8.93 165.81,8.88 165.69,8.88 165.63,8.93 165.63,9.87 165.43,10.08 165.43,10.86 165.61,11.04 167.16,11.04
+19V_GATE on BOTTOM (solid shape): 48.6,90.07 48.6,89.29 48.82,89.07 49.4,89.07 49.46,89.02 49.46,88.31 47.88,88.31 47.75,88.43 47.75,88.74 47.12,89.37 46.56,89.37 46.28,89.65 46.28,90.34 46.36,90.42 48.26,90.42
+19V_GATE1 on BOTTOM (solid shape): 50.85,89.43 51.64,89.43 51.84,89.22 51.84,88.38 51.56,88.1 50.57,88.1 50.42,88.26 50.42,88.89 49.84,89.48 49.07,89.48 48.97,89.58 48.97,90.21 49.07,90.31 49.96,90.31
+VCCST on IN2 (solid shape): outline of 1013 points within 34.18,54.67 51.98,60.2
+VDD_BATA_PACK on TOP (solid shape): 136.2,73.5 136.2,71.75 135.41,70.96 133.15,70.96 132.28,71.82 132.28,73.68 133.28,74.67 135.03,74.67
+VDD_BATA_PACK on BOTTOM (solid shape): 131.85,77.44 131.94,77.44 133.05,77.44 133.06,77.44 133.21,77.41 133.36,77.44 133.37,77.44 133.68,77.44 133.69,77.44 133.85,77.41 134,77.44 134.01,77.44 134.11,77.44 134.25,77.3 134.31,77.22 134.39,77.16 134.75,76.8 134.75,75.42 135.13,75.04 136.49,75.04 136.81,75.35 137.59,75.35 137.77,75.18 137.77,74.54 137.38,74.15 137.38,74.14 137.38,69.71 137.26,69.59 137.26,68.65 137.24,68.62 136.74,68.62 136.39,68.97 135.91,68.97 135.9,68.98 135.9,70.04 135.23,70.71 131.54,70.71 131.25,71 131.25,77.41 131.29,77.44 131.77,77.44
GND on TOP (solid shape): 37.52,22.29 37.52,18.69 30.51,18.69 30.51,22.36 30.63,22.48 37.33,22.48
GND on TOP (solid shape): 70.61,79.96 70.61,79.27 70.33,78.99 69.78,78.99 69.56,79.2 69.56,79.92 69.7,80.05 70.52,80.05
GND on TOP (solid shape): 88.57,27.65 88.57,24.55 87.71,23.69 87.15,23.69 86.82,24.02 86.82,27.91 86.93,28.02 88.2,28.02
GND on TOP (solid shape): 145.24,14.06 145.24,11.96 145.14,11.85 143.82,11.85 143.61,12.06 143.61,13.94 143.77,14.09 145.21,14.09
GND on TOP (solid shape): 158.42,59.28 158.42,58.39 158.07,58.03 157.3,58.03 157.25,58.08 157.25,59.5 157.28,59.53 158.17,59.53
GND on TOP (solid shape): 165.2,53.69 165.2,52.6 164.62,52.01 163.81,52.01 163.5,52.32 163.5,53.64 163.63,53.76 165.13,53.76
GND on TOP (solid shape): 169.06,15.28 169.06,14.32 168.94,14.19 166.35,14.19 166.12,14.42 166.12,15.03 166.55,15.46 168.89,15.46
GND on TOP (solid shape): 184.13,59.07 183.98,58.93 182.94,58.93 182.94,59.5 182.94,59.51 182.94,59.71 183.31,60.09 184.13,60.09
GND on TOP (solid shape): 105.89,62.37 106.47,62.37 106.65,62.19 106.65,61.58 106.6,61.53 105.77,61.53 105.3,61.99 105.3,62.41 105.48,62.59 105.68,62.59
GND on TOP (solid shape): 143.13,85.86 143.13,85.31 142.13,84.31 141.75,84.31 141.42,83.97 139.26,83.97 139.01,84.22 139.01,86.71 139.15,86.85 142.14,86.85
GND on TOP (solid shape): 182.88,62.81 182.88,62.25 182.67,62.03 182.28,62.03 181.99,61.74 181.92,61.74 181.66,61.99 181.66,62.76 181.79,62.88 182.81,62.88
GND on TOP (solid shape): 184.3,66.79 184.3,65.73 183.82,65.24 183.21,65.24 182.83,65.63 181.66,65.63 181.56,65.73 181.56,66.92 181.74,67.1 184,67.1
GND on TOP (solid shape): 6.93,54.1 6.93,53.85 6.8,53.72 6.18,53.72 5.91,53.44 5.91,52.85 5.79,52.73 5.51,52.73 5.34,52.9 5.34,53.98 5.63,54.27 6.77,54.27
GND on TOP (solid shape): 16.98,37.8 16.98,34.97 16.75,34.74 14.53,34.74 14.28,34.49 12.44,34.49 10.77,36.16 10.77,37.92 16.86,37.92
GND on TOP (solid shape): 165.15,11.7 165.15,10.51 164.57,9.92 162.92,9.92 162.76,10.08 162.76,10.41 162.89,10.53 163.7,10.53 163.93,10.76 163.93,12.03 164.06,12.16 164.7,12.16
GND on TOP (solid shape): 182.93,56.96 182.93,55.16 182.81,55.03 181.85,55.03 181.7,55.19 181.7,56.57 181.79,56.66 182.09,56.66 182.45,57.01 182.88,57.01
GND on TOP (solid shape): 82.98,79.42 82.98,77.3 82.91,77.23 80.68,77.23 79.7,78.21 79.7,78.79 79.73,78.96 79.7,79.13 79.7,79.53 79.95,79.78 82.62,79.78
GND on TOP (solid shape): 132.85,87.53 132.85,84.61 132.84,84.61 132.84,84.11 132.65,83.91 132.12,83.91 131.92,83.71 130.65,83.71 130.32,84.05 130.32,85.79 130.89,86.37 130.89,86.8 131.35,87.26 131.35,87.68 131.54,87.87 132.51,87.87
GND on TOP (solid shape): 30.95,85.08 30.95,83.73 30.77,83.55 30.77,82.1 30.88,81.98 31.14,81.98 31.2,81.93 31.2,81.56 31.13,81.49 29.76,81.49 29.61,81.63 29.61,82.02 30.03,82.43 30.03,85.01 30.18,85.16 30.87,85.16
GND on TOP (solid shape): 71.68,82.77 71.68,81.53 71.53,81.38 71.28,81.38 70.23,82.43 69.63,82.43 69.05,81.85 69.05,81.49 68.93,81.37 67.73,81.37 67.61,81.49 67.61,82 67.76,82.14 68.33,82.14 69.53,83.34 71.11,83.34
GND on TOP (solid shape): 150.17,14.31 150.37,14.32 150.73,13.96 150.73,13.25 150.6,13.12 148.72,13.12 148.54,12.95 148.54,11.98 148.4,11.84 147.96,11.84 147.83,11.97 147.83,14.14 148.01,14.32 150.08,14.32
GND on TOP (solid shape): 111.63,62.5 111.63,61.94 111.69,61.89 112.47,61.89 112.5,61.87 112.5,61.79 112.45,61.74 111.63,61.74 111.58,61.69 111.58,61.1 111.51,61.03 110.09,61.03 110.01,61.1 110.01,61.31 109.98,61.33 109.27,61.33 109.22,61.38 109.22,61.51 109.93,61.51 110.01,61.59 110.01,62.53 110.11,62.63 111.51,62.63
GND on TOP (solid shape): 72.8,73.5 72.8,73.07 72.67,72.94 70.55,72.94 70.11,72.94 68.5,72.94 68.4,72.84 68.39,72.83 68.33,72.77 68.33,71.84 68.52,71.64 69.21,71.64 69.24,71.61 69.24,70.79 68.91,70.46 68.91,70.35 68.89,70.32 68.89,69.89 68.73,69.74 68.15,69.74 67.77,70.12 67.77,73.06 68.34,73.63 72.67,73.63
GND on TOP (solid shape): 8.21,50.36 10.46,50.36 10.73,50.08 10.73,49.24 10.01,48.52 10.01,48.03 10.23,47.82 10.23,47.82 10.36,47.69 10.82,47.69 11.1,47.97 12.18,47.97 12.25,47.91 12.24,47.88 12.68,47.26 13.17,47.85 13.19,47.93 13.27,47.97 14.45,47.97 14.71,47.72 14.71,45.09 14.66,45.04 5.37,45.04 4.89,45.51 4.89,47.94 5.37,48.42 5.37,50.54 5.38,50.54 5.6,50.76 7.82,50.76
GND on TOP (solid shape): 135.38,58.86 135.41,58.85 135.44,58.81 135.48,58.76 135.52,58.72 135.56,58.68 135.61,58.65 135.67,58.63 135.72,58.62 135.78,58.61 135.84,58.62 135.9,58.63 135.95,58.65 136,58.68 136.04,58.7 136.08,58.7 136.59,58.19 136.59,56.65 136.05,56.1 134.59,56.1 133.92,56.78 133.92,57.32 135.08,57.32 135.08,57.26 135.09,57.21 135.11,57.15 135.14,57.1 135.17,57.06 135.21,57.02 135.26,56.98 135.31,56.95 135.36,56.93 135.41,56.92 135.47,56.91 135.53,56.91 135.58,56.92 135.64,56.94 135.69,56.97 135.74,57 135.78,57.04 135.81,57.08 135.84,57.13 135.87,57.18 135.88,57.23 135.89,57.29 135.89,57.35 135.88,57.4 135.87,57.46 135.84,57.51 135.81,57.56 135.78,57.6 135.74,57.64 135.69,57.67 135.64,57.7 135.58,57.71 135.53,57.72 135.47,57.73 135.41,57.72 135.36,57.71 135.31,57.69 135.26,57.66 135.21,57.62 135.17,57.58 135.14,57.54 135.11,57.49 135.09,57.43 135.08,57.38 135.08,57.32 133.92,57.32 133.92,58.81 133.93,58.84 133.94,58.85 133.97,58.86
GND on TOP (solid shape): outline of 89 points within 94.5,43.99 101.51,51
GND on TOP (solid shape): 152.45,77.39 152.45,73.93 152.21,73.69 145.7,69.34 149.92,75.94 151.56,77.58 152.26,77.58
GND on TOP (solid shape): outline of 196 points within 87.81,61.38 91.04,71.82
GND on TOP (solid shape): outline of 1020 points within 0.64,0.3 189.37,91.37
GND on BOTTOM (solid shape): 17.43,69.35 17.43,68.75 17.28,68.6 16.2,68.6 16.04,68.76 16.04,69.33 16.21,69.5 17.27,69.5
GND on BOTTOM (solid shape): 57.26,57.7 57.26,57.14 56.89,56.77 55.84,56.77 55.75,56.87 55.75,57.67 55.95,57.87 57.09,57.87
GND on BOTTOM (solid shape): 59.44,10.81 59.44,10.36 59.26,10.18 57.41,10.18 57.23,10.36 57.23,10.81 57.53,11.12 59.13,11.12
GND on BOTTOM (solid shape): 97.9,40.87 97.9,40.28 97.37,39.75 96.41,39.75 96.04,40.12 96.04,40.86 96.39,41.2 97.56,41.2
GND on BOTTOM (solid shape): 104.67,43.74 104.67,43.18 104.49,43 102.51,43 102.36,43.14 102.36,43.74 102.68,44.06 104.35,44.06
GND on BOTTOM (solid shape): 109.32,3.7 109.32,2.03 109.11,1.82 106.12,1.82 105.89,2.05 105.89,3.75 106.25,4.11 108.92,4.11
GND on BOTTOM (solid shape): 124.81,68.39 124.81,68.21 123.93,67.33 123.48,67.33 123.4,67.41 123.4,68.24 123.69,68.53 124.67,68.53
GND on BOTTOM (solid shape): 128.25,7.62 128.25,6.45 128.14,6.34 127.56,6.34 127.48,6.42 127.48,7.67 127.63,7.82 128.05,7.82
GND on BOTTOM (solid shape): 136.47,76.28 136.47,75.53 136.37,75.44 135.1,75.44 135.05,75.48 135.05,76.35 135.21,76.51 136.24,76.51
GND on BOTTOM (solid shape): 144.52,48.73 144.52,47.95 144.44,47.87 143.79,47.87 143.43,48.24 143.43,48.62 143.62,48.81 144.43,48.81
GND on BOTTOM (solid shape): 145.21,54 145.21,53.49 144.76,53.05 143.67,53.05 143.39,53.33 143.39,54.18 143.5,54.29 144.92,54.29
GND on BOTTOM (solid shape): 174.36,65.93 174.36,64.97 174.29,64.9 173.37,64.9 173.26,65.01 173.26,66.27 173.44,66.45 173.84,66.45
GND on BOTTOM (solid shape): 108.92,61.43 108.92,61.18 108.54,60.8 108.54,60.04 108.28,59.78 107.01,59.78 107.01,61.43 107.14,61.56 108.79,61.56
GND on BOTTOM (solid shape): 177.04,63.16 177.04,62.65 176.89,62.5 175.87,62.5 175.67,62.69 175.67,63.18 175.73,63.24 176.96,63.24
GND on BOTTOM (solid shape): 99.03,54.64 99.03,51.75 98.9,51.62 95.5,51.62 95.5,53.71 96.66,54.87 98.8,54.87
GND on BOTTOM (solid shape): 106.49,62.03 106.49,61.02 106.35,60.88 106.06,60.88 105.89,61.06 105.89,61.71 105.39,62.2 105.39,62.47 105.52,62.6 105.92,62.6
GND on BOTTOM (solid shape): 111.91,43.8 111.91,40.56 111.43,40.07 109.4,40.07 109.15,40.33 109.15,42.13 109.43,42.41 109.43,43.95 109.54,44.06 111.65,44.06
GND on BOTTOM (solid shape): 118.17,59.42 118.17,58.45 118.02,58.31 117.4,58.31 117.26,58.44 117.26,59.1 117.64,59.47 118.11,59.47
GND on BOTTOM (solid shape): 121.68,66.55 121.68,65.82 121.15,65.3 120.77,65.3 120.69,65.38 120.69,65.69 120.87,65.88 120.87,66.56 120.99,66.67 121.56,66.67
GND on BOTTOM (solid shape): 136.32,47.66 136.32,47.38 136.11,47.16 136.11,46.53 135.99,46.41 135.6,46.41 135.45,46.56 135.45,47.3 135.92,47.76 136.22,47.76
GND on BOTTOM (solid shape): 137.59,39.89 137.59,39.29 136.47,38.17 136.47,38.16 136.25,37.94 134.97,37.94 134.76,38.16 134.76,40.05 134.82,40.12 137.36,40.12
GND on BOTTOM (solid shape): 143.51,61.45 143.51,61.21 142.91,60.61 142.91,59.4 142.75,59.25 142.14,59.25 141.7,59.68 141.7,61.15 142.09,61.54 143.42,61.54
GND on BOTTOM (solid shape): 179.55,67.09 179.55,65.76 179.23,65.44 178.02,65.44 177.87,65.59 177.87,66.87 178.22,67.22 179.43,67.22
GND on BOTTOM (solid shape): 11.23,89.55 11.23,88.46 11.1,88.33 9.73,88.33 9.65,88.41 9.65,88.82 10.03,89.2 10.03,89.58 10.14,89.68 11.1,89.68
GND on BOTTOM (solid shape): 116.31,63.07 116.31,62.57 116.76,62.11 116.76,61.65 116.62,61.51 115.97,61.51 115.73,61.74 115.73,62.93 115.96,63.15 116.23,63.15
GND on BOTTOM (solid shape): 16.94,61.87 16.94,61.52 16.79,61.38 16.5,61.38 16.43,61.45 16.43,61.68 16.21,61.9 15.75,61.9 15.7,61.95 15.7,62.25 15.77,62.32 16.49,62.32
GND on BOTTOM (solid shape): 55.3,54.91 55.3,53.87 55.5,53.66 56.52,53.66 56.64,53.54 56.64,52.37 56.57,52.29 54.38,52.29 53.98,52.7 53.98,54.81 54.23,55.06 55.14,55.06
GND on BOTTOM (solid shape): 123.82,47.07 123.82,45.64 123.55,45.36 123.19,45.36 123.08,45.48 123.08,46.17 122.87,46.38 122.87,47.05 122.97,47.14 123.75,47.14
GND on BOTTOM (solid shape): 11.66,83.67 11.66,82.42 11.16,81.92 10.4,81.92 10.18,82.14 10.18,82.37 9.51,83.03 9.51,83.53 9.87,83.89 11.44,83.89
GND on BOTTOM (solid shape): 83.31,10.3 83.31,9.19 82.92,8.79 82.92,7.81 82.82,7.71 82.25,7.71 82.07,7.89 82.07,9.26 81.69,9.64 77.95,9.64 77.95,10.15 78.44,10.63 82.98,10.63
GND on BOTTOM (solid shape): 28.48,82.2 28.48,81.45 28.09,81.06 28.09,80.71 27.99,80.61 27.61,80.61 27.48,80.74 27.48,80.92 27.81,81.24 27.81,82.22 27.84,82.25 28.42,82.25
GND on BOTTOM (solid shape): 121.77,10.27 121.77,8.64 120.83,7.7 120.36,7.7 120.31,7.74 120.31,8.36 120.6,8.36 120.87,8.64 120.87,9.38 120.63,9.62 120.58,9.62 120.58,10.33 120.69,10.44 121.59,10.44
GND on BOTTOM (solid shape): 135.61,56.12 135.61,55.07 136.05,54.64 136.05,54.51 135.85,54.32 135,54.32 134.82,54.49 134.82,55.1 135.03,55.31 135.03,56.11 135.13,56.2 135.53,56.2
GND on BOTTOM (solid shape): 12.36,70.81 12.36,68.95 12.27,68.85 9.32,68.85 8.64,68.17 5.26,68.17 4.71,68.72 4.71,70.64 4.85,70.78 5.82,70.78 6.2,70.4 8.61,70.4 9.17,70.96 12.22,70.96
GND on BOTTOM (solid shape): 121.23,46.09 121.23,40.04 120.98,39.79 118.95,39.79 118.78,39.96 118.78,40.37 118.77,40.38 118.77,42.81 118.85,42.89 120.09,42.89 120.17,42.97 120.17,44.27 120.39,44.49 120.39,46.21 120.52,46.34 120.98,46.34
GND on BOTTOM (solid shape): 16.16,57.55 16.16,56.99 15.95,56.79 7.88,56.79 7.27,56.18 7.27,52.01 7.88,51.4 16.08,51.4 16.11,51.38 16.11,50.92 15.95,50.77 8.41,50.77 7.95,50.31 5.89,50.31 4.83,51.38 4.83,56.48 6.17,57.83 15.88,57.83
GND on BOTTOM (solid shape): 34.85,84.19 34.85,82.23 34.39,81.77 33.85,81.77 32.73,80.65 32.12,80.65 31.9,80.87 31.9,81.64 32.1,81.84 32.7,81.84 33.9,83.04 33.9,84.25 33.97,84.32 34.73,84.32
GND on BOTTOM (solid shape): 106.3,11.57 106.3,11.55 106.32,11.46 106.36,11.38 106.36,10.13 106.37,10.1 106.37,10.06 106.37,7.08 105.49,6.2 105.01,6.2 104.6,6.6 104.6,11.67 104.89,11.96 105.91,11.96
GND on BOTTOM (solid shape): 124.7,44 124.7,40.59 125,40.28 125,39.68 125.68,39 128.75,39 129.05,38.7 129.05,37.77 127.22,35.94 125.22,35.94 121.44,39.73 121.44,41.04 121.72,41.32 122.81,41.32 123.35,41.85 123.35,44.06 123.5,44.21 124.49,44.21
GND on BOTTOM (solid shape): 139.93,59.3 139.93,58.56 139.76,58.39 139.5,58.39 138.45,57.34 136.57,57.34 136.45,57.22 136.09,57.22 135.92,57.4 135.92,58.08 136.35,58.51 136.35,59.83 136.71,60.19 139.04,60.19
GND on BOTTOM (solid shape): 142.25,73.26 142.25,73.25 142.33,73.14 142.45,73.05 142.46,73.05 142.68,72.83 142.68,71.29 139.19,71.29 138.66,70.76 137.68,70.76 137.59,70.85 137.59,73.79 137.66,73.87 141.64,73.87
GND on BOTTOM (solid shape): 121.5,6.48 125.08,6.48 125.13,6.43 125.13,5.5 124.58,4.95 124.35,4.95 124.12,5.18 123.61,5.18 123.26,4.83 121.15,4.83 120.72,5.26 120.72,5.58 120.65,5.64 120.65,5.65 120.31,5.99 120.31,6.6 121.39,6.6
GND on BOTTOM (solid shape): 134.39,45.99 134.39,43.22 134.41,43.2 134.41,40.89 134.38,40.85 132.57,40.85 132.54,40.87 132.54,41.55 132.18,41.92 131.98,41.92 131.74,42.16 131.74,42.79 131.85,42.9 132.6,42.9 132.84,43.14 132.84,43.15 132.92,43.22 132.92,44.54 133.32,44.94 133.32,46.44 133.36,46.49 133.89,46.49
GND on BOTTOM (solid shape): 6.92,31.79 7.3,31.79 7.63,31.46 8.45,31.46 8.85,31.06 8.85,29.6 9.07,29.38 9.07,26.64 8.51,26.08 7.66,26.08 7.33,26.42 7.33,27.57 7.08,27.82 7.08,29.44 6.8,29.72 3.15,29.72 2.98,29.89 2.98,31.67 3.11,31.8 6.91,31.8
GND on BOTTOM (solid shape): 114.66,40.48 114.66,40.17 114.78,39.86 115.09,39.74 115.37,39.46 115.37,38.32 115.06,38.02 113.84,38.02 113.44,38.42 113.44,40.3 113.74,40.61 114.53,40.61
GND on BOTTOM (solid shape): 62.41,6.62 62.41,5.35 63.17,4.59 63.17,4.08 63.01,3.92 62.78,3.92 62.66,4.03 62.66,4.51 62.56,4.61 61.93,4.61 61.77,4.46 61.77,4.06 61.65,3.93 61.44,3.93 61.29,4.08 61.29,4.28 61.42,4.41 61.42,6.8 61.52,6.9 62.13,6.9
GND on BOTTOM (solid shape): 10.14,49.41 10.14,49.01 9.95,48.82 9.95,47.89 10.01,47.83 10.41,47.83 10.78,47.45 11.08,47.45 11.53,47 11.53,44.8 11.38,44.64 11.38,39.9 9.98,39.9 9.81,40.07 9.81,44.57 10.34,45.1 10.34,46.03 10.03,46.33 1.48,46.33 1.48,47.81 1.8,48.13 2.9,48.13 4.39,49.62 9.93,49.62
GND on BOTTOM (solid shape): 17.03,37.01 17.03,34.91 17.03,34.83 16.89,34.69 16.56,34.69 16.38,34.87 16.38,35.45 16.11,35.73 14.33,35.73 14.07,35.48 14.07,34.74 13.79,34.46 13.48,34.46 13.29,34.66 13.2,34.66 13.19,34.66 12.96,34.71 12.74,34.66 12.3,34.66 12.15,34.81 12.15,35.64 12.3,35.79 12.99,35.79 13.38,36.18 13.38,37.03 14.07,37.72 16.31,37.72
GND on BOTTOM (solid shape): 96.08,70.38 96.16,70.34 96.18,70.26 96.54,69.82 96.99,70.16 97.06,70.24 97.16,70.22 97.7,69.68 100.25,69.68 100.64,70.07 102.86,70.07 103.25,69.68 103.25,64.74 102.6,64.09 96.08,64.09 95.49,64.69 95.49,68.95 95.18,69.26 95.18,70.27 95.28,70.38
GND on BOTTOM (solid shape): 110.86,52.57 112.23,52.57 113.16,51.64 113.16,48.96 111.74,47.54 111.34,47.54 111.34,45.15 111,44.81 109.03,44.81 108.88,44.96 108.88,48.19 108.7,48.37 108.7,48.93 110.62,48.93 110.62,48.87 110.63,48.81 110.65,48.76 110.67,48.71 110.7,48.66 110.74,48.62 110.79,48.58 110.83,48.55 110.89,48.53 110.94,48.51 111,48.51 111.05,48.51 111.11,48.51 111.16,48.53 111.22,48.55 111.26,48.58 111.31,48.62 111.35,48.66 111.38,48.71 111.4,48.76 111.42,48.81 111.43,48.87 111.43,48.93 111.43,48.98 111.41,49.04 111.39,49.09 111.36,49.14 111.33,49.19 111.29,49.22 111.24,49.26 111.19,49.28 111.14,49.3 111.08,49.32 111.02,49.32 110.97,49.32 110.91,49.3 110.86,49.28 110.81,49.26 110.76,49.22 110.72,49.19 110.69,49.14 110.66,49.09 110.64,49.04 110.62,48.98 110.62,48.93 108.7,48.93 108.7,49.41 108.73,49.44 109.69,49.44 110,49.75 110,51.23 109.95,51.27 108.49,51.27 108.43,51.33 108.43,52.96 108.65,53.18 110.25,53.18
GND on BOTTOM (solid shape): 126.53,58.27 126.53,57.35 127.21,57.35 127.21,54.98 127.09,54.86 125.11,54.86 125.11,53.73 125.04,53.65 124.09,53.65 124,53.74 124,54.83 123.63,55.2 122.11,55.2 121.94,55.38 121.94,55.65 122.08,55.82 122.12,56.04 122.15,56.12 122.21,56.15 122.56,56.43 122.45,56.86 122.42,56.95 122.5,57.03 122.77,57.27 122.73,57.64 122.71,57.68 122.82,57.79 124.7,57.79 124.7,57.33 124.92,57.1 126,57.1 126.1,57.21 126.1,58.22 126.2,58.32 126.47,58.32
GND on BOTTOM (solid shape): outline of 89 points within 94.5,43.99 101.51,51
GND on BOTTOM (solid shape): outline of 101 points within 157,77.5 189.37,91.36
GND on BOTTOM (solid shape): outline of 1130 points within 0.64,0.29 189.37,91.37
GND on GND1 (solid shape): outline of 2925 points within 0.64,0.63 189.37,91.37
GND on IN1 (solid shape): outline of 818 points within 0.64,0.64 189.37,91.36
GND on IN2 (solid shape): outline of 818 points within 0.64,0.64 189.37,91.36
GND on VCC (solid shape): outline of 121 points within 39.32,30.32 88.98,62.32
GND on VCC (solid shape): outline of 383 points within 0.64,5.68 29.54,65.57
GND on VCC (solid shape): outline of 771 points within 49.1,0.63 189.37,91.37
GND on IN3 (solid shape): outline of 822 points within 0.64,0.64 189.37,91.36
GND on GND2 (solid shape): outline of 2859 points within 0.64,0.63 189.37,91.37
+1P05V on BOTTOM (solid shape): 56.14,81.19 56.14,80.43 55.38,79.67 55,79.67 54.52,80.14 54.52,81.09 54.77,81.34 55.99,81.34
+1P05V on BOTTOM (solid shape): 111.58,11.33 111.58,6.18 111.1,5.7 109.73,5.7 109.6,5.83 109.22,5.83 109.15,5.76 109.15,5.02 109.14,5.02 108.97,4.84 106.32,4.84 106.07,5.09 106.07,6.21 106.86,7.01 106.86,10.45 107.85,11.44 111.47,11.44
+1P05V on BOTTOM (solid shape): 12.08,37.54 12.08,37.34 12.29,37.12 12.96,37.12 13.07,37.02 13.07,36.22 12.87,36.02 12.14,36.02 11.87,35.75 11.87,34.78 12.43,34.22 12.43,33.83 12.38,33.78 11.62,33.78 11.11,34.29 11.11,35.74 11.4,36.02 11.4,37.63 11.53,37.77 11.86,37.77
+1P05V on VCC (solid shape): outline of 689 points within 22.28,8.6 111.71,63.72
+1P05V_BOOT1_D on BOTTOM (solid shape): 117.52,12.14 117.52,11.15 117.22,10.84 117.22,9.12 117.22,9.11 117.22,8.41 116.95,8.14 116.27,8.14 116.08,8.33 116.08,12.42 116.22,12.57 117.09,12.57
+1P05V_BOOT_D on BOTTOM (solid shape): 118.84,12.85 118.84,8.25 118.9,8.2 118.9,7.52 118.87,7.49 118.72,7.49 118.04,8.18 118.04,8.89 118.03,11.1 118.03,12.81 118.25,13.03 118.66,13.03
+1P05V_EDP on IN2 (solid shape): outline of 1388 points within 147.19,16.58 168.05,28.87
+1P05V_PHASE_D on BOTTOM (solid shape): 115.53,9.61 115.53,8.43 116.02,7.93 117.69,7.93 118.42,7.21 119.93,7.21 119.93,6 119.67,5.74 118,5.74 117.9,5.88 117.76,5.97 117.55,6.04 117.33,5.99 117.26,5.99 117.09,6.16 116.16,6.16 116.12,6.12 116.12,5.82 115.92,5.62 113.94,5.62 113.62,5.95 113.19,6.38 113.19,9.46 113.34,9.62 113.6,9.62 113.6,9.62 115.52,9.62
+1P05V_VDD_C on BOTTOM (solid shape): 120.2,11 120.2,9.69 120.17,9.66 120.16,9.66 120,9.5 119.73,9.5 119.29,9.06 119.29,7.7 119.11,7.7 119.11,8.46 119.1,8.47 119.1,11.1 119.23,11.23 119.97,11.23
+1P05V_VIN on BOTTOM (solid shape): 127.01,7.7 127.01,6.28 126.91,6.19 125.7,6.19 125.2,6.69 121.68,6.69 121.52,6.85 120.41,6.85 120.27,6.99 120.27,7.28 120.47,7.48 120.94,7.48 121.77,8.3 126.41,8.3
+1P35V_DUAL on TOP (solid shape): 111.32,60.1 111.51,59.91 112.05,59.91 112.05,59.9 112.18,59.9 112.26,59.83 112.26,59.33 112.21,59.28 111.77,59.28 111.55,59.5 111.47,59.5 111.13,59.84 111.13,60.76 111.32,60.76
+1P35V_DUAL on TOP (solid shape): 86.57,27.91 86.57,26.59 86.57,26.59 86.57,26.3 86.46,26.19 86.46,23.98 86.34,23.87 85.59,23.87 85.19,24.26 85.19,24.5 85.11,24.58 85.11,24.93 85.33,25.15 85.33,27.83 85.51,28.01 86.47,28.01
+1P35V_DUAL on TOP (solid shape): 70.66,72.53 70.66,70.81 70.99,70.48 70.99,70.34 71,70.33 71,69.59 70.84,69.44 69.46,69.44 69.37,69.55 69.26,69.63 69.25,69.63 69.11,69.77 69.11,70.38 69.45,70.59 69.45,70.98 69.45,71.22 69.5,71.41 69.45,71.6 69.45,71.61 69.45,71.7 69.29,71.85 68.61,71.85 68.53,71.92 68.53,72.69 68.58,72.74 70.46,72.74
+1P35V_DUAL on TOP (solid shape): 86.72,69.99 87.31,69.99 87.76,69.55 87.76,66.11 87.99,65.88 89.05,65.88 89.16,65.78 89.16,62.98 89.26,62.88 89.59,62.88 89.69,62.78 89.69,62.35 89.56,62.22 89.23,62.22 89.16,62.15 89.16,62.05 89.14,62.03 89.04,61.81 89.09,61.57 88.86,61.34 88.39,61.34 88.25,61.47 88.18,61.57 88.07,61.65 88.02,61.74 88.07,61.83 88.3,62.13 88.18,62.48 88.17,62.52 88.18,62.55 88.27,63 87.89,63.25 87.81,63.28 87.78,63.35 87.78,64.18 87.81,64.25 87.89,64.28 88.24,64.89 87.53,64.89 86.34,64.89 86.01,65.23 86.01,65.51 85.85,65.66 85.85,66.02 85.9,66.03 86.26,66.43 85.9,66.83 85.85,66.84 85.85,68.29 85.86,68.3 85.88,68.44 85.86,68.58 85.85,68.59 85.85,69.89 85.87,69.96 85.88,70.03 86.11,70.25 86.46,70.25
+1P35V_DUAL on BOTTOM (solid shape): 56.8,55.85 56.8,54.02 56.64,53.87 55.68,53.87 55.53,54.02 55.53,55.59 55.91,55.97 56.67,55.97
+1P35V_DUAL on BOTTOM (solid shape): 56.63,51.54 56.65,51.54 57.01,51.19 57.01,49.81 56.98,49.78 56.08,49.78 55.84,49.54 55.84,49.26 55.67,49.09 55.28,49.09 54.38,49.99 54.38,51.53 54.56,51.71 56.47,51.71
+1P35V_DUAL on BOTTOM (solid shape): 105.14,62.67 105.14,56.97 104.23,56.05 96.49,56.05 94.69,54.26 93.6,54.26 93.48,54.38 93.48,60.71 96.61,60.71 96.61,60.25 97.43,60.25 97.75,60.25 97.76,60.27 97.81,60.27 97.87,60.27 97.92,60.29 97.98,60.31 98.03,60.34 98.07,60.38 98.11,60.42 98.14,60.47 98.17,60.52 98.19,60.57 98.2,60.63 98.2,60.69 98.19,60.74 98.18,60.8 98.16,60.85 98.13,60.9 98.09,60.95 98.05,60.99 98,61.02 97.95,61.05 97.9,61.07 97.84,61.08 97.78,61.08 97.72,61.07 97.67,61.06 97.61,61.04 97.56,61.01 97.52,60.97 97.48,60.93 97.44,60.89 97.42,60.83 97.4,60.78 97.38,60.71 93.48,60.71 93.48,62.4 94.22,63.14 104.67,63.14
+1P35V_DUAL on BOTTOM (solid shape): outline of 3261 points within 52.81,37.63 87.99,72.93
+1P35V_DUAL on IN1 (solid shape): outline of 2053 points within 46.31,39.64 77.12,61.74
+1P35V_DUAL on IN2 (solid shape): outline of 3140 points within 68.15,62.58 88.37,72.69
