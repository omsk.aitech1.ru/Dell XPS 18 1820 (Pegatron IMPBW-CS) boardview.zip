# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_DDI1_TX1: length 188.1
  TOP w0.102: v1(166.17,50.11) 166.4,49.88 166.86,49.88 S1C4.1
  IN1 w0.127: v1(166.17,50.11) 166.4,49.88 167.34,49.88 168.51,48.71 168.51,47.37 166.3,45.16 166.3,41.44 165.76,40.91 162.81,40.91 159.2,37.3 157.84,37.3 154.66,34.13 146.43,34.13 135.82,23.51 118.29,23.51 117.68,24.12 105.26,24.12 104.02,22.89 102.32,22.89 100.07,20.64 94.72,20.64 94.26,21.1 92.18,21.1 91.34,20.26 90.11,20.26 84.41,14.55 84.41,14.17 83.84,13.61 77.59,13.61 77.27,13.29 66.35,13.29 66.01,12.95 62.56,12.95 61.8,13.71 54.71,13.71 51.36,17.06 45.16,17.06 42.17,20.06 39.96,20.06 39.18,20.85 30.76,20.85 29.67,21.94 24.24,21.94 20.91,25.27 20.91,26.61 19.2,28.31 19.2,30.5 18.47,31.24 18.47,31.72 v1(18.21,31.97)
  BOTTOM w0.089: U1.C58 21.96,32.47 21.64,32.78 21.36,32.78 21.24,32.66 19.31,32.66 19.03,32.38 18.62,32.38 v1(18.21,31.97)
DP_DDI1_TX1#: length 188.1
  TOP w0.102: S1C3.1 166.87,49.23 166.5,48.86 166.27,48.86 166.16,48.98 166.16,49.15 166.42,49.42 166.42,49.57 166.32,49.67 165.84,49.67 v1(165.41,50.11)
  IN1 w0.127: v1(18.87,31.97) 18.7,31.79 18.7,31.34 19.43,30.6 19.43,28.41 21.13,26.71 21.13,25.37 24.33,22.17 29.76,22.17 30.86,21.07 39.27,21.07 40.06,20.29 42.26,20.29 45.26,17.29 51.46,17.29 54.81,13.94 61.89,13.94 62.66,13.17 65.91,13.17 66.26,13.52 77.18,13.52 77.5,13.83 83.75,13.83 84.18,14.27 84.18,14.65 90.02,20.49 91.25,20.49 92.08,21.33 94.36,21.33 94.81,20.87 99.98,20.87 102.22,23.12 103.93,23.12 105.16,24.35 117.77,24.35 118.38,23.74 135.72,23.74 146.34,34.36 154.57,34.36 157.74,37.53 159.11,37.53 162.71,41.14 165.67,41.14 166.07,41.54 166.07,45.25 168.28,47.46 168.28,48.61 167.24,49.65 165.86,49.65 v1(165.41,50.11)
  BOTTOM w0.089: U1.B58 19.37,32.47 v1(18.87,31.97)
DP_DDI1_TX2: length 185.7
  TOP w0.102: S1C10.2 167.11,56.81 v1(165.91,56.81)
  IN1 w0.127: v1(165.91,56.81) 165.66,56.56 165.29,56.56 165,56.27 165,55.59 164.8,55.39 164.19,55.39 158.75,49.95 158.75,42.12 157.62,40.99 155.46,40.99 152,37.53 144.94,37.53 134.93,27.53 115.53,27.53 114.87,26.87 113.33,26.87 112.67,27.53 100.53,27.53 100.22,27.83 92.2,27.83 81.76,17.39 75.24,17.39 75.04,17.19 71.45,17.19 70.88,16.62 70.38,16.12 66.52,16.12 65.25,17.39 57.58,17.39 55.09,19.88 48.39,19.88 46.46,21.81 44.55,21.81 43.79,22.57 43.79,23.82 43.13,24.48 39.39,24.48 39.11,24.76 30.91,24.76 29.44,26.22 29.44,28.73 28.54,29.63 24.89,29.63 24.28,30.24 24.28,31.69 23.75,32.22 23.75,34.38 22.56,35.58 19.31,35.58 v1(18.85,35.12)
  BOTTOM w0.089: U1.A55 20.36,34.56 20.04,34.56 19.89,34.71 19.25,34.71 19,34.97
  BOTTOM w0.102: 19,34.97 v1(18.85,35.12)
DP_DDI1_TX2#: length 185.8
  TOP w0.102: S1C9.2 166.88,55.91 166.8,55.98 166.8,56.51 166.7,56.61 166.5,56.61 v1(165.91,56.02)
  IN1 w0.127: v1(19.48,35.12) 19.71,35.35 22.46,35.35 23.52,34.29 23.52,32.13 24.06,31.6 24.06,30.15 24.8,29.41 28.45,29.41 29.21,28.64 29.21,26.13 30.81,24.53 39.02,24.53 39.3,24.25 43.04,24.25 43.56,23.72 43.56,22.47 44.45,21.58 46.36,21.58 48.29,19.65 54.99,19.65 57.48,17.16 65.15,17.16 66.42,15.89 70.48,15.89 70.97,16.39 70.97,16.39 71.55,16.96 75.13,16.96 75.34,17.16 81.86,17.16 92.3,27.6 100.13,27.6 100.43,27.3 112.57,27.3 113.23,26.64 114.96,26.64 115.62,27.3 135.03,27.3 145.04,37.3 152.1,37.3 155.55,40.76 157.71,40.76 158.98,42.03 158.98,49.86 160.4,51.28 162.91,53.79 164.03,54.91 164.28,55.16 164.9,55.16 165.23,55.49 165.23,56.18 165.38,56.33 165.61,56.33 v1(165.91,56.02)
  BOTTOM w0.089: U1.B55 20.84,34.74 20.19,34.74 20.04,34.89 19.71,34.89 v1(19.48,35.12)
DP_DDI1_TX3: length 185.8
  TOP w0.102: S1C8.2 166.8,54.27 166.42,54.27 v1(166.12,54.58)
  IN1 w0.127: v1(166.12,54.58) 164.88,54.58 164.06,53.76 164.06,52.98 164.49,52.55 164.49,43.6 163.68,42.79 162.87,42.79 159.04,38.96 157.51,38.96 156.45,37.89 155.38,37.89 152.76,35.27 144.89,35.27 134.15,24.53 123.6,24.53 122.84,25.29 101.3,25.29 100.2,24.2 v4(99.9,24.2) 99.9,23.89 98.93,22.93 90.4,22.93 88.16,20.69 88.16,19.75 83.65,15.23 72.14,15.23 71.48,14.57 65.36,14.57 64.72,13.94 63.04,13.94 61.85,15.13 54.76,15.13 51.58,18.31 45.49,18.31 42.41,21.38 40.29,21.38 39.8,21.86 31.14,21.86 29.85,23.15 25.31,23.15 21.87,26.59 21.87,28.34 20.22,29.99 20.22,31.77 19.23,32.76 19.23,33.08 v1(19.64,33.48)
  BOTTOM w0.089: U1.B57 20.96,33.03 20.65,33.34 20.28,33.34 20.14,33.21 19.74,33.21 19.64,33.31 v1(19.64,33.48)
DP_DDI1_TX3#: length 185.8
  TOP w0.102: v1(166.12,53.79) 166.4,54.07 166.94,54.07 S1C7.2
  IN1 w0.127: v1(19,33.48) 19,32.66 19.99,31.67 19.99,29.89 21.64,28.24 21.64,26.49 25.21,22.92 29.76,22.92 31.05,21.63 39.71,21.63 40.19,21.15 42.32,21.15 45.39,18.08 51.49,18.08 54.66,14.9 61.76,14.9 62.95,13.71 64.82,13.71 65.45,14.34 71.57,14.34 72.23,15 83.75,15 88.39,19.65 88.39,20.6 90.16,22.36 90.49,22.7 99.03,22.7 101.39,25.06 122.74,25.06 123.5,24.3 134.24,24.3 144.98,35.04 152.85,35.04 155.47,37.66 156.54,37.66 157.61,38.73 159.13,38.73 162.97,42.56 163.77,42.56 164.72,43.51 164.72,52.65 164.29,53.08 164.29,53.66 164.97,54.35 165.56,54.35 v1(166.12,53.79)
  BOTTOM w0.089: v1(19,33.48) 19.45,33.03 U1.A57
DQA_ZQ1: length 11.4
  TOP w0.102: R30.1 85.62,29.43 84.91,30.14 81.52,30.14 80.34,28.97 80.34,28.17 U2.L8 79.98,27.81 80.32,27.46 80.32,26.87 80.24,26.78 80.24,26.02 v1(79.96,25.74)
  BOTTOM w0.102: v2(79.58,26.69) 79.96,26.31 v1(79.96,25.74)
DQA_ZQ2: length 4.9
  TOP w0.102: R31.1 80.85,43.26 80.85,41.75 80.34,41.24 80.34,40.02 79.98,39.66 U3.L8
DQA_ZQ3: length 18.7
  TOP w0.102: v2(88.19,57.9) 88.83,57.9 v1(88.95,58.03) 89.45,58.53 R32.1 ; U4.L8 79.98,58.95 80.32,58.61 80.32,58.21 80.12,58.01 79.95,58.01 79.82,57.88 v1(79.58,57.88)
  IN1 w0.102: v1(88.95,58.03) 88.95,57.67 85.61,54.32 81,54.32 80,55.32 80,57.46 v1(79.58,57.88)
DQA_ZQ4: length 10.6
  TOP w0.102: v2(88.19,70.2) 86.81,70.2 R33.1 84.6,72.41 80.7,72.41 80.39,72.1 80.39,70.88 80.2,70.69 U5.L8
DQA_ZQ5: length 7.1
  TOP w0.102: R34.1 81.54,30.45 79.98,28.89 U2.L9
DQA_ZQ6: length 4
  TOP w0.102: U3.L9 79.98,40.54 80.09,40.65 80.09,41.28 80.65,41.83 80.65,43.24 R35.1
DQA_ZQ7: length 22.1
  TOP w0.102: R36.1 89.87,59.94 v2(89.69,59.76) 89.23,59.3 v1(89.05,59.3) ; U4.L9 79.98,59.74 80.44,59.28 80.44,59.01 80.75,58.7 80.92,58.7 81.12,58.5 81.12,57.58 80.82,57.27 80.48,57.27 80.38,57.37 79.71,57.37 v1(79.58,57.24)
  IN1 w0.102: v1(89.05,59.3) 89.5,58.86 89.5,57.93 85.69,54.12 80.87,54.12 79.58,55.41 v1(79.58,57.24)
DQA_ZQ8: length 9.1
  TOP w0.102: U5.L9 79.98,72.47 79.97,72.48 80.5,73.01 85.09,73.01 R37.1 86.2,72.85 v2(86.34,72.99)
DSWODVREN: length 10.5
  BOTTOM w0.089: 47.75,67.14 47.38,66.76 47.38,65.17 46.53,64.33 45.28,64.33 45.23,64.28 44.92,63.97 42.78,63.97 U1.AW7
  BOTTOM w0.102: 47.75,67.14 47.93,67.31 47.93,67.7 v2(48.35,68.12) PR2.2
DTM_AC_OFF: length 80.3
  TOP w0.102: v1(112.63,72.69) 112.63,72.57 v2(113.32,71.87)
  IN2 w0.254: v1(141.99,43.91) 146.52,43.91 151.18,48.57 151.18,61.82 145.85,67.16 145.85,72.89 143.96,74.78 141.75,74.78 140.92,73.96 122.39,73.96 121.62,73.18 117.36,73.18 116.38,72.2 113.13,72.2 v1(112.63,72.69)
  BOTTOM w0.178: U10.97 112.98,73.05 v1(112.63,72.69)
  BOTTOM w0.254: v1(141.99,43.91) 141.99,43.81 141.54,43.36 PQ13.5 PQ13.2 138.05,43.36 PR77.1
EC_RST#: length 35.3
  TOP w0.102: R229.2 106.54,71.17 D8.3 105.75,71.82 C88.1 104.9,70.97 104.9,70.02 v1(105.03,69.89) 105.25,69.68 v2(105.25,69.21)
  IN1 w0.127: v1(97.77,81.5) 97.99,81.28 105.99,81.28 106.61,80.66 106.61,80.01 105.8,79.2 103.42,79.2 101.3,77.08 101.3,76.6 100.28,75.58 100.28,74.9 101.37,73.8 102.01,73.8 102.49,73.32 102.49,72.69 103.2,71.98 103.2,71.72 v1(105.03,69.89)
  BOTTOM w0.102: U10.14 97.87,80.93 97.77,81.04 v1(97.77,81.5) 97.77,81.82 SC5.1
EC_XIN: length 10.2
  BOTTOM w0.102: U10.128 100.58,73.42 100.41,73.25 99.36,73.25 98.81,72.69 98.81,71.52 98.32,71.04 v2(96.65,71.04) 96.46,71.23 R210.1 96.11,72.03 95.99,72.14 C80.1 95.53,72.51 95.4,72.64 R216.1 94.57,73.13 R212.1
EC_XOUT: length 8.5
  BOTTOM w0.102: 97.3,72.85 97.3,72.03 R210.2 ; 97.3,72.85 R211.1 ; 97.3,72.85 97.63,72.85 97.79,72.69 97.79,72.25 v2(98.27,71.77) 98.55,72.05 98.55,72.72 99.96,74.13 99.96,75.94 99.77,76.13 U10.2
EDID_CLK: length 47.5
  TOP w0.102: U6.49 166.79,19.92 166.98,19.73 166.98,18.69 167.68,17.99 R136.2 168.59,17.57 170.18,17.57 v1(170.61,18) 170.99,17.62 v2(171.3,17.62) ; C128.1 149.27,10.93 v1(149.1,10.76)
  IN1 w0.102: v1(170.61,18) 170.61,17.75 169.52,16.65 169.52,8.98 164.98,4.44 150.42,4.44 148.52,6.34 148.52,8.71 149.1,9.29 v1(149.1,10.76)
  BOTTOM w0.102: v1(149.1,10.76) 148.75,10.41 P2.3
EDID_DATA: length 47.4
  TOP w0.102: v1(149.94,10.76) 150.36,11.18 C129.1 ; U6.50 167.03,20.32 167.42,19.93 167.42,19.11 167.64,18.89 R138.2 168.2,18.89 168.63,18.46 170.31,18.46 v1(170.69,18.84) 170.54,18.99 v2(170.54,19.58)
  IN1 w0.102: v1(149.94,10.76) 149.94,9.59 148.9,8.55 148.9,6.49 150.57,4.82 164.82,4.82 169.27,9.26 169.27,16.81 170.13,17.67 170.13,18.28 v1(170.69,18.84)
  BOTTOM w0.102: P2.4 149.25,10.07 v1(149.94,10.76)
EDP_AUXN: length 193.3
  TOP w0.102: v2(173.19,26.84) 172.9,26.84 ; 172.9,26.84 172.9,28.55 171.38,30.07 169.55,30.07 v1(165.76,33.85) ; 172.9,26.84 172.9,24.63 172.07,23.8 R125.1 R128.2 170.05,23.8 169.98,23.73 C65.2
  IN3 w0.089: 18.44,40.99 v1(18.36,41.06)
  IN3 w0.114: v1(165.76,33.85) 165.36,33.44 164.64,33.44 163.2,34.89 158.85,34.89 157.71,33.75 141.48,33.75 136.27,28.54 120.45,28.54 118.16,30.83 95.61,30.83 83.85,19.07 78.17,19.07 75.58,16.48 68.94,16.48 68.15,17.26 60.22,17.26 59.84,16.88 53.6,16.88 52.57,17.91 46.7,17.91 44.06,20.55 41.26,20.55 40.87,20.95 38.72,20.95 38.03,21.63 34.6,21.63 34.16,22.06 34.16,23.24 32.77,24.63 31.02,24.63 29.14,26.52 29.14,28.78 28.75,29.16 28.75,31.57 27.69,32.63 27.15,32.63 26.95,32.43 26.37,32.43 25.91,32.88 25.91,33.55 25.17,34.28 23.94,34.28 22.43,35.79 22.43,36.7 21.34,37.79 21.34,39.22 20.15,40.4 19.02,40.4 18.44,40.99
  BOTTOM w0.102: v1(18.36,41.06) 18.64,40.78 18.64,40.66 18.89,40.42 20.38,40.42 U1.A45
EDP_AUXN_C: length 2.9
  TOP w0.102: U6.60 166.52,24.32 166.61,24.4 167.02,24.4 167.29,24.13 168.32,24.13 C65.1
EDP_AUXP: length 193.3
  TOP w0.102: v1(165.13,33.88) 165.58,33.42 165.91,33.42 169.46,29.86 171.3,29.86 172.7,28.47 172.7,25.26 ; v2(172.4,25.26) 172.7,25.26 ; 172.7,25.26 172.7,24.71 171.99,24.01 171.81,24.01 171.73,24.08 171.73,24.2 171.88,24.35 171.88,24.54 171.83,24.59 R124.1 R127.2 170.01,24.59 169.95,24.65 C66.2
  IN3 w0.089: 19.05,40.99 19.05,41.04 v1(19.04,41.05)
  IN3 w0.114: v1(165.13,33.88) 164.92,33.67 164.74,33.67 163.29,35.12 158.76,35.12 157.62,33.98 141.38,33.98 136.18,28.77 120.54,28.77 118.26,31.06 95.51,31.06 83.75,19.3 78.08,19.3 75.48,16.71 69.03,16.71 68.24,17.49 60.13,17.49 59.75,17.11 53.69,17.11 52.66,18.14 46.79,18.14 44.15,20.78 41.36,20.78 40.96,21.18 38.81,21.18 38.13,21.86 34.69,21.86 34.39,22.16 34.39,23.33 32.87,24.86 31.12,24.86 29.36,26.61 29.36,28.87 28.98,29.25 28.98,31.67 27.79,32.86 27.06,32.86 26.86,32.66 26.46,32.66 26.14,32.98 26.14,33.64 25.27,34.51 24.03,34.51 22.66,35.88 22.66,36.8 21.57,37.89 21.57,39.31 20.25,40.63 19.13,40.63 19.05,40.71 19.05,40.99
  BOTTOM w0.102: U1.B45 20.86,40.86 20.29,40.86 20.03,40.61 18.97,40.61 18.83,40.74 18.83,40.84 v1(19.04,41.05)
EDP_AUXP_C: length 3.2
  TOP w0.102: 167.74,24.34 167.37,24.34 167.11,24.6 166.63,24.6 166.51,24.72 U6.61 ; 167.74,24.34 168.41,24.34 C66.1 ; 167.74,24.34 v2(167.74,24.63)
EDP_DISP_UTIL: length 8.2
  BOTTOM w0.089: U1.A43 20.2,41.93 19.92,41.65 19.22,41.65 18.9,41.98 17.3,41.98
  BOTTOM w0.102: HT95.1 14.26,42.45 14.73,41.98 17.3,41.98
EDP_HPD: length 257
  TOP w0.102: v1(175.85,36.57) 175.85,36.85 171.78,40.91 166.9,40.91 v1(163.4,44.42) ; v1(166.88,23.41) 166.77,23.52 U6.58 ; v1(14.93,74.52) 14.99,74.45 R99.1 14.79,73.88 14.5,74.17 14.5,74.9 R95.1
  IN1 w0.102: v1(166.88,23.41) 168.12,24.66 168.12,25.78 168.99,26.64 168.99,28.36 171.38,30.75 171.38,34.48 173.46,36.57 v1(175.85,36.57)
  IN2 w0.102: v1(14.93,74.52) 14.93,74.54 15.2,74.81 15.2,76.51 17.95,79.27 19.02,79.27 21.88,82.13 23.01,82.13 25.35,84.48 31.13,84.48 31.28,84.63 35.84,84.63 37.46,86.24 37.95,86.24 38.48,85.71 51.67,85.71 52.19,85.19 55.97,85.19 56.21,84.94 61.08,84.94 61.39,85.25 64.83,85.25 65.32,85.74 66.29,85.74 67.11,86.56 73.68,86.56 74.86,87.74 88.51,87.74 89.84,86.4 92.64,86.4 93.16,86.93 97.71,86.93 98.92,85.72 112.83,85.72 114.91,83.63 119.72,83.63 120.32,84.23 130.23,84.23 130.89,84.89 141.04,84.89 141.54,84.38 142.77,84.38 145.79,81.36 156.49,81.36 157.76,80.09 159.56,80.09 160.63,81.16 164.73,81.16 167.84,78.04 167.84,70.99 166.12,69.27 166.12,59.9 163.36,57.15 163.36,44.45 v1(163.4,44.42)
  BOTTOM w0.089: U1.D6 21.54,64.44 21.47,64.37 21.02,64.37 20.83,64.56 18.48,64.56 17.95,65.09
  BOTTOM w0.102: v2(15.39,75.23) 15.39,74.98 v1(14.93,74.52) 14.78,74.37 14.78,71.77 15.01,71.54 16.16,71.54 17.95,69.76 17.95,65.09
EDP_TXN0: length 177.5
  TOP w0.102: C62.1 165.12,30.39 165.33,30.6 165.33,30.85 v1(165.15,31.03)
  IN3 w0.114: v1(165.15,31.03) 164.49,31.69 141.58,31.69 136.88,26.99 101.3,26.99 100.03,25.72 93.31,25.72 88.05,20.46 87.57,20.46 85.98,18.87 85.98,18.4 84.11,16.53 77.73,16.53 76.07,14.88 65.46,14.88 64.29,13.71 62.7,13.71 61.35,15.05 48.08,15.05 46.73,16.4 45.95,16.4 43.26,19.09 40.64,19.09 40.27,19.46 38.07,19.46 37.37,20.16 33.71,20.16 32.31,21.56 31.05,21.56 29.62,22.98 28.79,22.98 24.77,27 24.77,27.81 22.07,30.5 22.07,31.93 20.78,33.22 20.78,34.47 19.62,35.63 19.12,35.63 16.79,37.95 16.79,40.14 17.03,40.38 17.03,40.4 17.43,40.8 v1(17.43,40.84)
  BOTTOM w0.089: U1.C45 21.61,40.55
  BOTTOM w0.102: v1(17.43,40.84) 18.01,40.84 18.22,40.63 18.39,40.63 18.8,40.23 21.29,40.23 21.61,40.55
EDP_TXN0_C: length 4
  TOP w0.102: U6.4 164.09,27.23 164.16,27.3 164.16,27.89 164.27,28 ; C62.2 165.51,28.8 165.51,28.38 165.35,28.21 164.48,28.21 164.27,28 ; 164.27,28 v2(164.07,28.21)
EDP_TXN1: length 176.2
  TOP w0.102: v1(163.09,33.24) 163.48,32.86 163.48,32.4 ; v2(163.18,32.4) 163.48,32.4 ; 163.48,32.4 163.48,31.78 163.93,31.33 163.93,30.54 163.82,30.44 163.46,30.44 163.3,30.6 163.3,30.9 163.2,31.01 162.94,31.01 162.84,30.9 162.84,30.33 C64.1
  IN3 w0.114: v1(163.09,33.24) 162.46,33.88 159.26,33.88 158.32,32.94 141.76,32.94 136.63,27.8 118.59,27.8 118.34,28.06 93.93,28.06 83.9,18.03 83.16,18.03 82.45,17.31 77.45,17.31 75.75,15.61 68.56,15.61 67.72,16.45 62.92,16.45 62.28,15.82 53.52,15.82 52.17,17.16 46.33,17.16 43.66,19.83 40.95,19.83 40.57,20.21 38.41,20.21 37.73,20.9 34.19,20.9 32.92,22.17 32.92,23.27 32.39,23.79 29.72,23.79 27.61,25.9 27.61,28.11 26.21,29.51 24.65,29.51 24.18,29.97 24.18,31.47 22.4,33.25 22.4,34.06 21.29,35.18 21.29,36.3 20.58,37.01 20.58,38.86 19.77,39.67 19.1,39.67 19,39.57 19,39.45 v1(19.25,39.19)
  BOTTOM w0.089: 20.42,39.52 20.28,39.66 19.12,39.66 19,39.54 19,39.45 v1(19.25,39.19)
  BOTTOM w0.102: U1.A47 20.42,39.52
EDP_TXN1_C: length 2.8
  TOP w0.102: C64.2 163.53,28.8 163.53,28.69 162.99,28.15 162.99,27.25 162.89,27.15 U6.7
EDP_TXP0: length 177.5
  TOP w0.102: v1(165.84,31.03) 165.53,30.73 165.53,30.61 165.64,30.5 165.94,30.5 166.11,30.33 C61.1
  IN3 w0.114: v1(165.84,31.03) 165.41,31.46 165.05,31.46 164.59,31.92 141.49,31.92 136.79,27.22 101.2,27.22 99.93,25.95 93.21,25.95 87.95,20.69 87.48,20.69 85.75,18.97 85.75,18.49 84.02,16.76 77.63,16.76 75.98,15.1 65.36,15.1 64.19,13.94 62.79,13.94 61.44,15.28 48.17,15.28 46.82,16.63 46.04,16.63 43.35,19.32 40.74,19.32 40.37,19.69 38.17,19.69 37.47,20.39 33.8,20.39 32.41,21.79 31.14,21.79 29.72,23.21 28.88,23.21 25,27.09 25,27.91 22.3,30.6 22.3,32.02 21.01,33.32 21.01,34.56 19.71,35.86 19.21,35.86 17.02,38.05 17.02,40.05 17.12,40.15 v1(17.43,40.15)
  BOTTOM w0.102: U1.B46 21.44,40.03 18.72,40.03 18.31,40.44 18.14,40.44 17.95,40.63 17.79,40.63 17.43,40.26 v1(17.43,40.15)
EDP_TXP0_C: length 4
  TOP w0.102: C61.2 165.72,28.8 165.72,28.29 165.61,28.19 ; U6.3 164.49,27.25 164.36,27.37 164.36,27.8 164.57,28.01 165.43,28.01 165.61,28.19 ; 165.61,28.19 v2(165.82,27.98)
EDP_TXP1: length 176.2
  TOP w0.102: 164.13,31.03 164.13,31.42 163.68,31.87 v1(163.68,33.67) ; 164.13,31.03 v2(164.42,31.03) ; 164.13,31.03 C63.1
  IN3 w0.114: v1(18.62,39.22) 18.77,39.37 18.77,39.66 19.01,39.9 19.86,39.9 20.8,38.96 20.8,37.1 21.52,36.39 21.52,35.27 22.63,34.15 22.63,33.34 24.41,31.56 24.41,30.07 24.74,29.74 26.31,29.74 27.84,28.2 27.84,25.99 29.81,24.02 32.49,24.02 33.15,23.36 33.15,22.26 34.28,21.12 37.82,21.12 38.51,20.44 40.67,20.44 41.05,20.06 43.76,20.06 46.43,17.39 52.27,17.39 53.61,16.04 62.19,16.04 62.82,16.68 67.81,16.68 68.65,15.84 75.66,15.84 77.36,17.54 82.36,17.54 83.07,18.25 83.8,18.25 93.84,28.29 118.43,28.29 118.69,28.03 136.53,28.03 141.66,33.16 158.22,33.16 159.16,34.1 162.55,34.1 162.99,33.67 v1(163.68,33.67)
  BOTTOM w0.102: U1.B47 20.75,39.84 19.04,39.84 18.82,39.62 18.82,39.42 v1(18.62,39.22)
EDP_TXP1_C: length 2.8
  TOP w0.102: U6.6 163.29,27.19 163.2,27.28 163.2,28.07 163.73,28.6 163.73,28.79 C63.2
EN_RXD1: length 5.5
  TOP w0.102: T35.1 21,80.73 21.79,80.73 22.38,81.31 22.38,82.35 21.77,82.97 21.77,84.02 22.03,84.29 U13.5
EN_RXD2: length 1.7
  TOP w0.102: v1(32.35,82.28) 32.35,82.44 32.57,82.66 U14.5
  BOTTOM w0.102: v1(32.35,82.28) 32.31,82.24 T37.1
EQ_11: length 6
  TOP w0.178: v2(18.96,82.18) 19.18,82.4 R327.1 20.47,82.84 20.47,83.35 20.4,83.43 20.4,83.9 20.8,84.3 20.91,84.3 21.02,84.41 21.02,85.27 21.53,85.79 U13.2
EQ_12: length 21
  TOP w0.254: v1(27.95,85.56) 27.64,85.56 27.5,85.43 R329.1 27.3,84.96 26.48,85.79 U13.17 ; v1(20.99,86.78) 20.16,86.78 19.75,86.36 R324.2
  IN2 w0.254: v1(18.84,83.48) 19.03,83.68 23.37,83.68 25.05,85.36 27.75,85.36 27.95,85.56 v1(27.95,85.56)
  IN3 w0.254: v1(18.84,83.48) 18.84,83.9 20.99,86.06 v1(20.99,86.78)
  BOTTOM w0.102: v2(19.78,82.42) 19.21,82.42 18.84,82.79 v1(18.84,83.48)
EQ_21: length 2.3
  TOP w0.254: U14.2 32.43,84.16 31.72,83.46 31.43,83.46 R335.1
EQ_22: length 5.4
  TOP w0.254: U14.17 37.38,84.16 37.52,84.29 37.52,84.47 38.21,85.16 38.66,85.16 R337.1 39.37,85.87 39.47,85.87 v2(39.8,86.2) 40.5,85.5 R332.2
EXT_SCI#: length 90.7
  TOP w0.089: RN8.1 44.05,69.8 43.82,69.56 43.19,69.56 42.95,69.81 42.67,70.08 42.67,70.27 42.04,70.91 v1(41.73,70.91)
  TOP w0.102: v1(92.13,86.86) v2(92.13,88.51)
  IN1 w0.102: v1(82.17,86.89) 82.86,87.57 89.18,87.57 90.5,86.25 91.52,86.25 v1(92.13,86.86)
  IN2 w0.102: v1(87.45,74.95) 87.15,75.24 83.29,75.24 82.56,74.52 77.73,74.52 76.84,75.4 67.39,75.4 66.78,74.8 64.6,74.8 63.48,73.68 58.23,73.68 57.31,74.59 52.5,74.59 51.55,73.64 44.39,73.64 43.82,73.07 43.82,72.53 43.63,72.34 43.17,72.34 v1(41.73,70.91)
  BOTTOM w0.089: U1.AN2 38.61,67.52 38.61,68.09 38.72,68.2 38.72,68.8 38.6,68.93
  BOTTOM w0.102: 38.6,68.93 38.57,68.96 38.57,69.59 38.9,69.93 39.52,69.93 39.94,70.35 41.17,70.35 v1(41.73,70.91) ; D7.1 92.83,87.57 v1(92.13,86.86) ; v1(82.17,86.89) 83.52,85.54 83.52,82.96 82.16,81.6 82.16,77.88 84.07,75.97 86.43,75.97 v1(87.45,74.95)
EXT_SMI#: length 120.5
  TOP w0.102: v2(104.24,77.58) 104.24,77.94 103.61,78.57 D6.1 103.61,79.82 v1(104.03,80.23)
  IN1 w0.102: v1(36.08,75.59) 36.63,75.05 37.14,75.05 37.35,75.26 39.51,75.26 39.52,75.28 40.74,75.28 41.06,75.59 41.06,77.89 40.18,78.77 40.18,79.67 39.3,80.56 36.92,80.56 v1(36.68,80.8)
  IN2 w0.102: v1(21.85,75.84) 23.14,77.13 23.72,77.13 25.7,79.11 27.8,79.11 29.04,80.36 32.62,80.36 33.54,81.27 35.43,81.27 35.91,80.8 v1(36.68,80.8) 38.03,80.8 38.17,80.94 38.58,80.94 40.15,82.5 40.86,82.5 41.99,81.37 43.81,81.37 44.94,82.51 48.75,82.51 49.09,82.86 55.21,82.86 55.63,82.43 62.28,82.43 63.06,83.2 66.73,83.2 67.77,84.24 81.69,84.24 81.9,84.03 81.9,82.99 82.28,82.61 86.24,82.61 86.8,82.05 88.94,82.05 89.32,81.67 92.28,81.67 92.63,82.02 94.24,82.02 95.18,81.08 98.06,81.08 98.86,81.89 101.28,81.89 v1(101.73,82.34)
  BOTTOM w0.089: U1.AG5 34.89,65.7 34.89,66.81 34.94,66.86 34.94,68.25 34.65,68.54 34.65,68.93 34.93,69.21 35.16,69.21 35.61,69.66 35.61,70.59 35.66,70.64 35.66,70.65
  BOTTOM w0.102: v1(104.03,80.23) 103.57,80.69 103.2,80.69 102.62,81.27 102.33,81.27 101.73,81.87 v1(101.73,82.34) ; SR4.2 22.04,75.64 v1(21.85,75.84) ; v1(36.08,75.59) 36.08,73.74 35.68,73.34 35.68,72.98 35.66,72.97 35.66,70.65
FAN0_PWM: length 114.2
  TOP w0.102: v1(97.34,88.43) 97.34,88.93 v2(97.52,89.12)
  IN2 w0.089: 16.77,64.4 v1(17.05,64.12)
  IN2 w0.102: 16.77,64.4 14.43,66.74 14.43,70.86 13.41,71.88 v1(13.41,73.4) 13.41,74.26 13.77,74.62 13.77,75.94 15.19,77.36 15.19,79.41 16.66,80.88 16.66,84.19 17,84.53 17.58,84.53 18.08,85.03 22.24,85.03 25.43,88.22 38.06,88.22 39.09,87.18 53.51,87.18 53.78,86.91 54.46,86.91 54.69,87.14 56.45,87.14 57.16,86.43 59.54,86.43 59.88,86.77 66.17,86.77 66.77,87.37 73.24,87.37 74.67,88.8 94.02,88.8 94.88,87.94 96.85,87.94 v1(97.34,88.43)
  BOTTOM w0.102: v1(97.34,88.43) 97.34,88.34 97.54,88.13 U10.32 ; Q20.2 12.08,73.59 12.4,73.27 13.28,73.27 v1(13.41,73.4) ; R277.1 16.49,63.05 16.79,63.35 16.79,63.87 v1(17.05,64.12)
FAN0_PWM_Q: length 17.4
  BOTTOM w0.102: v2(7.04,70.93) 8.61,70.93 10.14,72.46 Q20.3 11.13,71.39 11.36,71.16 12.44,71.16 12.57,71.03 12.57,69.38 12.88,69.08 12.88,68.11 12.7,67.94 12.7,66.79 13.37,66.12 CON7.2 15.11,66.12 15.84,65.4 R276.2 16.24,64.69 16.29,64.63 R277.2
FAN0_TACH: length 134.6
  TOP w0.089: R278.2 20.5,62.42 20.5,62.42 C116.1
  TOP w0.102: R278.2 20.13,61.21 18.31,61.21 18.09,61.43 18.09,62.96 18.14,63.01 18.14,63.7 v1(17.72,64.12)
  IN2 w0.089: 16.77,65.07 v1(17.72,64.12)
  IN2 w0.102: v1(104.71,86.99) 104.26,86.53 99.25,86.53 98.04,87.74 94.8,87.74 93.94,88.6 74.76,88.6 73.32,87.16 66.85,87.16 66.25,86.56 59.96,86.56 59.62,86.22 58.47,86.22 57.6,85.35 56.38,85.35 56.09,85.64 54.07,85.64 52.73,86.98 39.01,86.98 38.48,87.51 36.88,87.51 36.56,87.19 33.49,87.19 32.67,88.01 25.51,88.01 22.33,84.83 18.16,84.83 17.66,84.33 17.09,84.33 16.87,84.11 16.87,80.8 15.39,79.33 15.39,77.28 14.25,76.14 14.25,74.82 13.95,74.51 13.95,71.65 14.63,70.96 14.63,67.21 16.77,65.07
  BOTTOM w0.089: v2(17.43,64.76) 17.43,64.41 v1(17.72,64.12)
  BOTTOM w0.102: v1(104.71,86.99) 104.71,87.38 105.23,87.9 105.64,87.9 106.18,88.44 U10.47 ; v1(17.72,64.12) 17.33,63.72 17.2,63.72 16.99,63.52 16.99,62.88 16.66,62.55 15.52,62.55 15.34,62.37 15.34,60.82 15.55,60.62 15.55,59.35 15.28,59.09 D13.1
FF_ON: length 29.7
  TOP w0.102: v1(174.22,80.99) 173.81,81.4 172.62,81.4 171.72,82.3 170.3,82.3 168.2,84.4 U16.9
  BOTTOM w0.102: v1(174.22,80.99) 175.41,79.8 175.41,79.02 176.87,77.56 176.87,75.75 177.55,75.07 178.18,75.07 v2(182.14,71.11) 183.8,69.46 R235.1 183.31,67.91 183.21,68.02 Q5.5
FF_ON_D: length 21.9
  TOP w0.102: R234.2 183.57,53.28 v1(183.34,53.05) 183.85,53.05 v2(184.15,52.75)
  BOTTOM w0.102: Q5.3 181.36,68.67 181.51,68.52 181.51,68.24 181.29,68.02 Q5.2 180.15,68.02 179.91,67.78 179.91,66.9 180.6,66.21 180.62,66.21 182.68,64.15 182.68,63.06 184.46,61.28 184.46,54.17 v1(183.34,53.05)
FF_ON_O: length 12.2
  TOP w0.102: v1(184.2,62.27) 183.94,62.53 R232.2
  BOTTOM w0.102: v1(184.2,62.27) 184.2,63.65 T29.1 181.56,66.29 181.56,66.9 182.04,67.37 Q5.6 183.08,67.37 183.38,67.08 R235.2 186.62,67.08 CON3.P11
FF_ON_PCH: length 170.5
  TOP w0.102: v1(142.77,76.27) 143.44,76.93 144.88,76.93 146.25,78.3 146.25,78.91 146.64,79.29 148.69,79.29 149.35,79.96 v1(149.35,83.2) ; v1(166.06,86.76) 166.07,86.76 165.43,87.39 v2(165.36,87.39) 164.77,87.39 163.83,86.45 SR9208.2 163.63,85.63 U16.11
  IN1 w0.102: v1(166.06,86.76) 165.76,86.45 157.25,86.45 153.09,82.3 150.25,82.3 v1(149.35,83.2)
  IN2 w0.089: 27.1,70.93 27.08,70.92 27.08,67.83 v1(28.11,66.8)
  IN2 w0.102: 27.1,70.93 29.29,73.12 29.29,74.83 30.38,75.91 30.38,77.42 31.5,78.54 32.55,78.54 33.84,79.82 37.05,79.82 37.22,79.99 38,79.99 38.41,79.58 40.43,79.58 41.01,80.15 44.31,80.15 45.16,81.01 46.15,81.01 46.54,80.62 48.58,80.62 49.6,81.64 54.7,81.64 55.13,81.21 60.66,81.21 61.48,80.38 65.63,80.38 67.63,82.38 69.36,82.38 69.69,82.71 76.45,82.71 78.05,81.11 82.92,81.11 83.4,81.59 85.6,81.59 86.16,81.03 88.52,81.03 88.95,80.6 92.69,80.6 92.99,80.29 94.53,80.29 94.76,80.07 98.62,80.07 99.42,80.87 101.83,80.87 102.05,81.08 107.7,81.08 107.92,80.87 108.17,80.87 109.16,79.88 109.16,79.8 109.76,79.2 113.72,79.2 114,78.92 120.34,78.92 120.73,79.31 120.73,79.67 121.4,80.34 127.34,80.34 127.61,80.62 135.44,80.62 139.06,76.99 142.05,76.99 v1(142.77,76.27)
  BOTTOM w0.089: U1.P3 28.41,66.5 v1(28.11,66.8)
FORCE_OFF#: length 114.7
  TOP w0.102: Q3.3 106.25,73.27 107.05,72.47 D8.2 110.01,72.47 110.21,72.67 v1(110.21,72.94) 110.21,73.32 109.37,74.16 109.37,75.39 109.13,75.64 108.36,75.64 108.15,75.43 Q3.6 ; v1(98.49,74.31) 98.49,74.43 97.99,74.93 94.58,74.93 93.44,73.79 90.08,73.79 89.49,74.39 89.14,74.39 87.66,75.86 83.78,75.86 83.57,76.07 83.57,76.28 82.88,76.97 82.46,76.97 82.46,76.97 80.54,76.97 79.36,78.16 76.8,78.16 75.9,79.07 75.9,81.61 75.49,82.01 74.12,82.01 73.24,82.88 U12.4 ; v1(157.83,69.48) 157.58,69.23 157.58,66.51 158.29,65.8 T9206.1 158.29,62.09 158.15,61.95 Q9200.3
  IN2 w0.102: v1(98.49,74.31) 109.53,74.31 110.21,73.63 v1(110.21,72.94)
  IN3 w0.102: v1(157.83,69.48) 157.31,69.48 156.67,70.12 146.2,70.12 144.48,71.85 133.58,71.85 132.41,73.02 118.37,73.02 117.62,72.27 110.61,72.27 110.21,72.67 v1(110.21,72.94)
GPIO2: length 11.5
  BOTTOM w0.089: 24.29,69.66 24.29,68.79 25.02,68.06 25.02,67.45 25.13,67.35 25.13,66.9 U1.J3
  BOTTOM w0.102: 24.29,69.66 24.29,70.27 23.38,71.18 23.38,72.76 23.31,72.84 23.31,73.18 23.65,73.52 23.7,73.52 SR50.2 23.91,73.74 23.52,74.13 23.52,74.15 23.43,74.24 23.43,75.03 23.59,75.19 23.81,75.19 24.03,75.4 v2(24.03,76.27)
GPIO3: length 10
  TOP w0.102: v2(25.25,73.88) 25.13,73.76 SR88.2 24.08,73.3 24.14,73.24 24.14,72.71 24.11,72.68 24.11,70.88 24.46,70.53 24.46,69.71 25.1,69.07 v1(25.1,69.05)
  BOTTOM w0.089: v1(25.1,69.05) 25.18,68.98 25.18,68.66 25.77,68.06 25.77,67.36 25.82,67.31 25.82,66.15 U1.J4
GPIO38: length 12.6
  TOP w0.102: v1(25.35,75.97) 25.62,75.7 SR9209.2
  BOTTOM w0.089: 26.59,70.65 26.78,70.46 26.78,70.33 27.03,70.08 27.03,68.95 27.27,68.7 27.27,67.44 U1.L2
  BOTTOM w0.102: 26.59,70.65 25.81,71.43 25.81,74.7 26.42,75.3 26.42,75.48 ; 26.42,75.48 26.42,75.48 26.99,75.48 27.17,75.67 v2(27.51,75.67) ; 26.42,75.48 25.93,75.97 25.35,75.97 v1(25.35,75.97)
GPIO39: length 10.7
  TOP w0.089: v1(30.59,59.87) SR9210.2 31.88,59.4 v2(31.88,57.77)
  IN3 w0.089: v1(30.59,59.87) 29.69,60.77 28.53,60.77 28.04,61.26 28.04,62.68 27.74,62.98 27.74,64.39 v1(27.3,64.82)
  BOTTOM w0.089: U1.N5 27.46,64.82 v1(27.3,64.82)
GPIO66: length 11.7
  TOP w0.089: v1(22.19,66.12) 20.61,67.7 20.27,67.7 19.89,68.08 19.89,68.48 18.8,69.56 18.42,69.56 v2(17.65,70.32) 18.41,70.32 18.76,70.68
  TOP w0.102: 18.76,70.68 SR89.1 19.74,71.66 19.74,71.68 19.77,71.71 19.77,72.62 19.35,73.05 SR90.2
  BOTTOM w0.089: v1(22.19,66.12) 22.55,66.48 U1.D3
GPIO86: length 14.1
  TOP w0.089: 24.26,69.07 24.26,68.7 25.68,67.28 25.68,66.67 26.9,65.45 26.9,64.01 27.32,63.59 v1(27.32,63.58)
  TOP w0.102: v2(20.88,73.32) 20.88,71.8 SR87.2 22.49,71.25 SR86.1 23.13,70.6 23.83,70.6 24.26,70.17 24.26,69.07
  BOTTOM w0.089: U1.L8 26.92,63.22 27.28,63.58 v1(27.32,63.58)
GPIO_R: length 6.7
  TOP w0.102: U6.16 159.29,26.96 159.11,27.14 158.32,27.14 157,28.47 157,28.8 R60358.2 156.27,28.85 155.87,28.85 155.35,29.37 v2(155.35,30.42)
GYRO_INT1: length 21.2
  TOP w0.102: UA3.7 161.8,59.33 160.94,60.19 160.94,60.52 159.72,61.74 159.72,65.41 160.78,66.48 160.78,69.15 161.39,69.76 v2(161.39,70.35) 161.39,71.47 160.3,72.56 159.56,72.56 v1(158.98,71.98)
  BOTTOM w0.102: U20.30 159.81,72.81 v1(158.98,71.98)
H_CPU_SVIDALRT#: length 7.5
  BOTTOM w0.089: 28.5,25.37 27.93,25.94 27.59,25.94 26.83,26.7 26.83,27.78 27.23,28.18 27.23,29.54 U1.L62
  BOTTOM w0.102: HR24.2 28.65,24.66 28.91,24.91 v2(28.91,25.19) 28.68,25.19 28.5,25.37
H_CPUPWRGD_R: length 8
  TOP w0.102: HT2.1 19.14,27.68 v1(20.03,26.79) HR5.2
  BOTTOM w0.089: v1(20.03,26.79) 19.67,27.15 19.67,30.13 20.29,30.74 20.81,30.74 20.89,30.83 21.31,30.83 21.34,30.8 U1.C61
H_LP4+: length 13.8
  BOTTOM w0.102: L6.1 33.06,89.46 32.72,89.12 31.99,89.12 D11.1 31.2,89.16 26.55,89.16 25.26,87.88 25.26,84.05 25,83.79 CN1.3
H_LP4-: length 13.8
  BOTTOM w0.102: CN1.4 26,83.72 25.9,83.82 25.55,83.82 25.47,83.9 25.47,87.8 26.63,88.96 31.07,88.96 D12.1 32.04,88.92 32.72,88.92 33.02,88.61 L6.4
H_PECI_EC: length 190.3
  TOP w0.089: R114.1 29.71,23.08
  TOP w0.102: v1(117.27,21.68) 118.16,22.57 v2(118.16,27.47) 118.16,31.31 116.87,32.61 v1(116.87,33.7) ; v1(27.48,11.9) 26.87,12.51 26.87,17.9 28.12,19.15 28.12,21.28 28.72,21.87 C201.1 29.71,22.3 29.71,23.08
  IN1 w0.127: v1(104.85,76.65) 104.85,76.42 103.9,75.47 103.9,75.01 104.14,74.77 106.56,74.77 108.61,72.71 108.74,72.71 109.17,72.28 109.86,72.28 110.77,71.37 110.77,69.33 111.43,68.67 111.43,64.28 111.89,63.82 111.89,61.16 111.54,60.81 110.99,60.81 110.7,60.52 110.7,58.96 109.74,58 109.74,45.61 111.11,44.23 111.11,41.06 111.32,40.86 111.32,40.44 116.87,34.89 v1(116.87,33.7)
  IN3 w0.102: v1(54.56,5.81) 58.4,5.81 59.16,5.05 77.29,5.05 77.93,5.68 79.1,5.68 80.87,7.45 85.55,7.45 87.46,5.54 91.81,5.54 93.68,7.41 94.05,7.41 96.92,10.28 102.09,10.28 104.46,12.65 109.18,12.65 116.16,19.63 117.27,20.74 v1(117.27,21.68)
  BOTTOM w0.102: v1(104.85,76.65) 104.85,75.53 104.98,75.4 U10.117 ; v1(27.48,11.9) 29.47,11.9 31.82,14.26 40.09,14.26 44.11,10.24 44.11,5.51 45,4.61 49.35,4.61 50.37,3.6 53.11,3.6 54.56,5.05 v1(54.56,5.81)
H_PROCHOT#: length 22.3
  TOP w0.102: v1(36.55,18.03) 36.16,18.42 31.43,18.42 30.65,17.63 27.45,17.63 v1(27.38,17.7)
  BOTTOM w0.102: HR4.1 27.48,22.46 HR3.2 HR2.2 27.05,20.98 27.05,18.03 v1(27.38,17.7) v2(27.38,16.93) ; HQ1.3 38.08,19.38 PC219.1 37.37,19.95 36.77,19.36 36.55,19.14 v1(36.55,18.03)
H_PROCHOT#_D: length 7.9
  BOTTOM w0.089: U1.K63 26.2,28.2 26.47,27.93 26.47,26.44 25.88,25.85 25.88,25.6 25.66,25.37
  BOTTOM w0.102: 25.66,25.37 25.63,25.34 25.63,24.91 25.91,24.63 26.39,24.63 v2(26.85,25.09) 27.18,25.09 27.41,24.86 27.41,24.42 27.48,24.35 HR4.2
H_THRMTRIP#: length 165.8
  TOP w0.102: SR15.2 19.8,24.33 20.02,24.33 v2(20.55,23.79) 20.39,23.63 SR18.2 18.56,23.63 18.26,23.33 v1(18.16,23.33)
  IN1 w0.127: v1(18.16,23.33) 18.03,23.33 17.65,22.96 17.65,22.34 22.09,17.91 25.89,17.91 26.11,18.13 27.66,18.13 28.14,17.64 30.1,17.64 30.71,17.04 33.76,17.04 33.99,17.26 43.05,17.26 46.92,13.4 51.72,13.4 52.75,12.37 61.25,12.37 61.91,11.71 66.49,11.71 66.85,11.35 80.24,11.35 81.08,12.18 84.76,12.18 86.68,14.1 87.57,14.1 90.04,16.58 v1(90.04,17.01)
  IN3 w0.102: v1(115.98,66.76) 115.98,67.65 114.95,68.68 114.19,68.68 113.69,68.19 109.66,68.19 108.84,69 106.12,69 105.22,68.1 95.82,68.1 95.06,67.34 93.99,67.34 92.2,65.55 92.2,57.19 91.26,56.25 90.66,56.25 v1(90.05,56.86)
  BOTTOM w0.102: v1(90.05,56.86) 89.64,56.45 89.64,54.22 89.89,53.97 89.89,45.46 90.37,44.97 90.37,41.62 89.59,40.84 89.59,20.01 89.41,19.83 89.41,17.75 90.04,17.11 v1(90.04,17.01) ; v1(115.98,66.76) 115.8,66.57 Q4.2
HDA_BCLK_R: length 11
  BOTTOM w0.089: 47.75,63.87 46.61,62.73 43.55,62.73 43.47,62.65 42.78,62.65 U1.AW8
  BOTTOM w0.102: 47.75,63.87 48.19,64.3 48.19,66.21 48.44,66.46 v2(49.07,66.46) 49.89,67.28 AR1.1
HDA_RST#_R: length 13.3
  TOP w0.089: AR3.1 46.89,56.51 46.05,55.67 45.57,55.67 45.52,55.62 43.91,55.62 43.59,55.93 43.59,56.97 42.73,57.84 42.73,59.8 42.23,60.29 41.35,60.29 v2(41.2,60.44) 40.88,60.76 v1(40.88,61.05)
  BOTTOM w0.089: U1.AU8 41.19,62.94 40.88,62.64 v1(40.88,61.05)
HDA_SDO_R: length 28.6
  TOP w0.089: 48.16,57.09 46.35,57.09 45.77,56.51 44.31,56.51 42.9,57.92 42.9,59.87 42.31,60.47 42.11,60.47 v1(41.53,61.05)
  TOP w0.102: v1(53.85,64.94) v2(53.85,63.57) 53.85,62.87 53.98,62.74 53.98,62.5 53.34,61.87 53.34,61.03 52.5,60.19 52.5,58.3 51.29,57.09 48.16,57.09
  BOTTOM w0.089: U1.AU11 41.19,61.42 41.53,61.08 v1(41.53,61.05)
  BOTTOM w0.102: Q1.3 50.83,65.16 50.72,65.27 AR4.1 50.15,65.25 50.91,64.48 52.83,64.48 53.29,64.94 v1(53.85,64.94)
HDA_SYNC_R: length 8.5
  TOP w0.089: v1(42.15,61.06) 42.87,61.06 v2(43.23,60.7) 43.64,60.29 43.64,59.21 44.19,58.66 44.19,58.07 44.43,57.83 45.77,57.83 45.87,57.73 47.14,57.73 47.21,57.8 AR2.1
  BOTTOM w0.089: v1(42.15,61.06) 41.84,61.36 U1.AV11
HIERR#_G: length 8.8
  TOP w0.102: CR8.1 111.14,76.36 110.83,76.05 R243.2 110.83,74.79 111.14,74.49 Q12.3 111.14,72.83 110.9,72.59 110.9,69.21 v2(111.33,68.78)
HOMEKEY_BTN#: length 175.4
  TOP w0.102: v1(50.87,79.52) 50.87,80.22 49.99,81.09 D2.2 ; v1(115.72,21.66) 115.72,27.3 115.52,27.5 115.52,33.88 v1(115.11,34.28) ; v1(107.11,82.32) 107.56,81.88 R173.2 107.56,80.5 107.44,80.38 T54.1 107.77,79.29 v1(107.77,77.99)
  IN1 w0.102: v1(115.11,34.28) 115.11,35.42 110.45,40.09 110.45,40.5 108.99,41.97 108.99,42.31 108.99,42.32 108.99,45.13 108.87,45.25 108.87,58.36 109.27,58.76 109.27,59.68 109.46,59.87 109.46,60.76 109.32,60.9 109.32,68.59 108.35,69.57 108.35,70.93 106.07,73.21 104.27,73.21 102.61,74.87 102.61,75.59 103.01,76 103.01,77.85 103.57,78.41 107.35,78.41 v1(107.77,77.99)
  IN2 w0.102: v1(50.87,79.52) 50.87,78.16 51.14,77.88 58.11,77.88 58.91,77.08 63.91,77.08 64.16,77.33 68.03,77.33 68.93,78.24 74.21,78.24 75.11,77.33 88.05,77.33 88.71,78 88.71,78.91 89.1,79.3 91.47,79.3 92.23,78.54 96.14,78.54 97.29,77.39 97.85,77.39 99.33,78.87 106.9,78.87 v1(107.77,77.99)
  BOTTOM w0.102: v1(115.11,34.28) 115.11,35.68 T53.1 ; U10.70 109.99,86.13 107.11,83.25 v1(107.11,82.32) ; v1(115.72,21.66) 115.72,21.54 122.77,14.5 125.78,14.5 129.85,10.43 132.56,10.43 132.89,10.76 134.11,10.76 134.5,10.37 CON9.3
HOMEKEY_BTN#_R: length 23.3
  TOP w0.089: 42.46,71.57 42.46,70.74 43.14,70.06 v1(43.26,70.06)
  TOP w0.102: 42.46,71.57 42.46,72.13 42.63,72.3 42.63,72.9 43.2,73.47 46.07,73.47 v2(46.59,73.98) 48.31,75.71 49.32,75.71 50.19,76.58 50.19,78.29 49.99,78.5 D2.1
  BOTTOM w0.089: 42.09,69.44 42.09,68.67 41.51,68.09 41.51,67.5 U1.AU2 ; v1(43.26,70.06) 43.49,70.29 43.49,70.65
  BOTTOM w0.102: 43.49,70.65 43.49,71.09 R119.2 43.81,70.91 43.97,70.74 43.97,70.19 43.43,69.64 43.08,69.64 42.96,69.77 42.42,69.77 42.09,69.44
HOMEKEY_DET#: length 169.5
  TOP w0.102: v1(88.22,17.01) 87.83,17.39 87.3,17.93 82.83,17.93 82.83,17.92 80.58,17.92 79.6,16.94 78.9,16.94 78.18,16.22 77.47,16.22 77.27,16.02 73.24,16.02 72.72,16.54 72.56,16.54 71.6,17.49 71.6,17.96 70.22,19.35 69.28,19.35 v1(69.09,19.54) ; R146.2 136.73,10.47 v2(136.73,10.41) 136.73,10.16 v1(135,8.43)
  IN2 w0.102: v1(135,8.43) 133.52,6.95 117.4,6.95 115.84,5.39 102.27,5.39 101.16,6.51 99.74,6.51 99.43,6.82 99.43,11.14 98.95,11.62 92.06,11.62 88.67,15 88.67,16.73 88.39,17.01 v1(88.22,17.01)
  IN3 w0.089: 24.72,40.99 24.66,41.04 24.66,47.2 26.67,49.21 26.67,53.43 27.51,54.27 27.51,55.72 28.76,56.97 28.76,58.48 27.79,59.45 27.79,62.27 26.85,63.21 26.85,63.75 v1(27.3,64.2)
  IN3 w0.102: 24.72,40.99 24.72,37.03 27.38,34.36 30.63,34.36 31.15,33.84 31.15,32.8 31.8,32.15 31.8,26.97 35.36,23.41 43.05,23.41 44.65,21.81 45.59,21.81 48.36,19.04 59.51,19.04 59.62,18.93 68.48,18.93 v1(69.09,19.54)
  BOTTOM w0.089: U1.L6 26.99,64.52 v1(27.3,64.2)
  BOTTOM w0.102: CON9.2 v1(135,8.43)
HOMEKEY_LED_ON#: length 94.5
  TOP w0.102: v1(116.44,21.66) 116.44,28.55 116.25,28.73 116.25,29.39 v2(116.26,31.16) 116.26,31.87 116,32.12 v1(116,33.75) ; v1(131.59,14.76) Q39.1 131.27,13.34 R349.2
  IN1 w0.102: v1(116,33.75) 115.55,34.21 115.55,35.28 110.66,40.17 110.66,40.59 110.45,40.79 110.45,43.96 109.73,44.68 109.73,44.68 109.48,44.93 109.07,45.33 109.07,58.27 109.48,58.67 109.48,59.49 109.73,59.74 109.73,60.91 109.63,61.01 109.63,68.58 108.55,69.65 108.55,71.01 106.15,73.41 104.36,73.41 102.81,74.95 102.81,75.51 103.21,75.91 103.21,77.46 v1(103.53,77.78)
  BOTTOM w0.102: U10.20 100.73,83.33 101.26,82.81 101.26,82.06 102.35,80.97 102.52,80.97 102.97,80.51 102.97,79.37 103.53,78.81 v1(103.53,77.78) ; v1(131.59,14.76) 122.79,14.76 116.44,21.12 v1(116.44,21.66)
HOMEKEY_LED_ON#_Q: length 9.8
  TOP w0.102: Q39.3 130.61,11.89 130.79,11.71 R349.1 v2(131.27,8.68) 131.47,8.48 v1(132.5,8.48)
  BOTTOM w0.102: CON9.7 v1(132.5,8.48)
HOST_ALERT1#_R: length 17.1
  TOP w0.089: 33.83,70.68 33.4,70.25 32.69,70.25 31.9,69.47 31.9,68.44 31.44,67.98 31.44,67.44 31.9,66.97 31.9,66.24 32.55,65.59 32.55,65.21 v1(33.04,64.73)
  TOP w0.102: v2(35.98,77.18) 35.54,76.74 SR28.2 34.61,76.74 34.01,76.14 34.01,75.61 34.63,74.99 34.63,73.02 34.67,72.97 34.67,71.52 33.83,70.68
  BOTTOM w0.102: U1.AD6 33.25,64.52 v1(33.04,64.73)
HSIO_PWR_CNTL: length 55.5
  IN2 w0.102: v1(62.13,83.46) 62.13,83.46 61.73,83.06 55.86,83.06 55.46,83.46 48.84,83.46 48.5,83.12 44.69,83.12 43.6,82.03 42.19,82.03 41.12,83.11 39.89,83.11 38.7,81.92 v1(37.7,81.92)
  BOTTOM w0.089: 30.68,68.93 30.68,68.45 31.12,68.02 31.12,67.52 U1.Y2
  BOTTOM w0.102: 30.68,68.93 30.68,70.7 31.28,71.29 31.71,71.29 32.27,71.85 32.27,73.01 31.95,73.32 31.95,75.1 32.36,75.51 32.36,76.9 33.14,77.67 33.14,79.4 33.22,79.49 v2(33.22,80.23) 33.22,80.86 33.64,81.27 37.05,81.27 v1(37.7,81.92) ; PQ5.2 61.89,89.51 61.8,89.43 61.8,88.23 61.62,88.05 61.22,88.05 60.94,87.77 60.94,87.08 PR53.2 PR54.1 62.13,85.83 62.13,83.46 v1(62.13,83.46)
I2C1_SCL_IO: length 95.8
  TOP w0.102: v1(177.67,76.57) 176.86,77.39 T72.1 ; UA3.2 164.41,55.82 v1(164.55,55.96) ; U17.4 160.09,82.18 160.22,82.31 160.79,82.31 161.59,81.52 161.59,80.36 161.77,80.17 161.77,79.32 162.13,78.96 163.73,78.96 164.19,78.5 164.19,76.06 165.22,75.04 165.64,75.04 166.09,75.48 v1(166.7,75.48) 166.7,75.07 165.74,74.11 165.74,73.52 165.1,72.88 165.1,71.8 164.33,71.04 163.03,71.04 161.08,69.08 161.08,66.41 160.43,65.77 160.43,64.46 161.62,63.26 162.74,63.26 v1(163.12,62.88) ; v1(155.91,52.29) 155.53,52.29 154.46,53.36 154.46,54.94 154.56,55.04 U19.4 ; v1(155.02,69.59) 155.02,69.51 155.23,69.3 R60370.2
  IN1 w0.127: v1(177.67,76.57) 169.47,76.57 169.24,76.34 166.93,76.34 166.7,76.12 v1(166.7,75.48)
  BOTTOM w0.102: v1(155.91,52.29) 156.29,52.67 156.29,53.56 156.98,54.25 159.74,54.25 160.42,54.93 163.02,54.93 164.05,55.96 v1(164.55,55.96) 164.89,56.3 164.89,57.89 163.12,59.66 v1(163.12,62.88) 163.54,63.3 163.54,63.81 162.1,65.24 155.44,65.24 153.96,66.72 153.96,68.86 154.23,69.13 154.56,69.13 v1(155.02,69.59) 156.16,70.73 156.16,73.93 154.43,75.67 U20.13 ; v1(166.7,75.48) 167.88,75.48 R258.1 ; R356.2 178.16,77.06 v1(177.67,76.57)
I2C1_SCL_IO_G: length 4.1
  BOTTOM w0.102: v2(165.74,67.44) 166.19,67.9 166.19,68.75 R254.2 165.18,69.77 Q15.1
I2C1_SCL_IO_R: length 8.8
  BOTTOM w0.102: CON11.4 178.25,83.66 177.81,83.22 C187.1 177.97,82.67 R355.2 177.97,81.25 177.36,80.64 177.08,80.64 176.61,80.17 176.61,78.72 v2(177.14,78.19) R356.1
I2C1_SDA_IO: length 98.6
  TOP w0.102: v1(154.38,69.59) 154.38,69.51 154.32,69.45 R60371.2 ; UA3.3 164.27,56.47 164.47,56.67 v1(164.47,56.74) ; v1(155.91,51.53) 156.33,51.95 156.33,52.46 155.89,52.9 U19.6 ; v1(179.02,81.2) 178.26,81.96 T71.1 ; U17.6 161.84,81.62 161.84,80.51 162.03,80.32 162.03,79.42 162.24,79.21 163.84,79.21 164.44,78.61 164.44,76.22 165.2,75.46 v1(165.47,75.46) 165.91,75.9 166.88,75.9 167.12,75.65 167.12,73.92 165.35,72.15 165.35,71.7 164.44,70.78 163.14,70.78 161.33,68.98 161.33,66.31 160.68,65.66 160.68,64.56 161.73,63.52 v1(163.12,63.52)
  IN1 w0.127: v1(179.02,81.2) 179.02,79.72 179.45,79.29 179.45,78.63 177.9,77.08 169.57,77.08 169.22,76.73 166.74,76.73 v1(165.47,75.46)
  BOTTOM w0.102: R357.2 179.02,81.31 v1(179.02,81.2) ; R260.1 v1(165.47,75.46) ; v1(155.91,51.53) 155.49,51.95 155.49,52.46 156.03,53.01 156.03,53.67 156.87,54.51 159.64,54.51 160.32,55.19 162.92,55.19 v1(164.47,56.74) 164.47,57.85 162.69,59.63 162.69,63.09 v1(163.12,63.52) 163.12,63.87 162,64.99 155.04,64.99 153.71,66.32 153.71,69.17 154.12,69.59 v1(154.38,69.59) 155.46,70.67 155.47,70.67 155.72,70.91 155.72,70.92 155.91,71.11 155.91,73.8 154.4,75.31 U20.12
I2C1_SDA_IO_G: length 3.3
  BOTTOM w0.102: Q16.1 168.41,69.98 168.37,69.94 R252.2 169.04,68.6 v2(169.72,68.6)
I2C1_SDA_IO_R: length 5.8
  BOTTOM w0.102: v2(177.17,80.03) 177.66,80.03 R354.2 178.21,80.99 178.39,81.17 178.39,81.51 R357.1 178.73,82.29 178.83,82.39 C186.1 178.83,83.23 178.73,83.33 178.73,83.64 178.75,83.66 CON11.5
INT_PIRQA#: length 9.1
  TOP w0.089: 28.83,66.46 28.98,66.62 v2(28.98,67.2)
  TOP w0.102: RN4.4 25.62,70.66 26.32,69.97 26.57,69.97 27.43,69.11 27.43,69.06 27.67,68.83 27.92,68.83 28.98,67.76 v2(28.98,67.2) ; v1(29.23,64.7) 28.83,65.11 28.83,66.46
  BOTTOM w0.089: v1(29.23,64.7) 29.23,64.7 29.41,64.52 U1.U6
INT_PIRQB#: length 8.3
  TOP w0.102: v1(28.24,65.42) 28.53,65.71 28.53,66.96 28.08,67.4 27.64,67.4 27.07,67.97 27.07,69.18 26.49,69.76 26.25,69.76 25.12,70.88 RN4.6
  BOTTOM w0.089: v1(28.24,65.42) 28.52,65.7 U1.P4
INT_PIRQC#: length 7.8
  TOP w0.089: 25.72,68.94 25.72,68.15 26.04,67.84 26.04,66.73 v1(27.32,65.44) ; v2(25.48,69.71) 25.72,69.47
  TOP w0.102: RN4.8 24.52,70.82 24.72,70.63 25.05,70.63 25.48,70.2 v2(25.48,69.71) ; 25.72,69.47 25.72,68.94
  BOTTOM w0.089: U1.N4 27.7,65.81 v1(27.32,65.44)
INT_PIRQD#: length 5.9
  TOP w0.089: v1(27.84,69.23) 28.37,69.23 v2(28.53,69.08)
  TOP w0.102: RN4.2 26.22,70.59 27.33,69.49 27.59,69.49 v1(27.84,69.23)
  BOTTOM w0.089: U1.N2 27.73,67.38 28.02,67.67 28.02,68.91 27.84,69.09 v1(27.84,69.23)
JTCKC: length 5.1
  TOP w0.102: v2(155.09,75.3) 155.26,75.14 156.83,75.14 v1(157.25,75.56) 157.6,75.56 R430.1
  BOTTOM w0.102: v1(157.25,75.56) 157.61,75.56 157.93,75.88 U20.20
JTMSC: length 3.6
  TOP w0.102: R428.1 161.05,74.21 160.99,74.28 v2(160.99,74.92) 160.63,74.92 v1(160.22,74.52)
  BOTTOM w0.102: U20.26 160.52,74.81 v1(160.22,74.52)
KSI0: length 8.6
  TOP w0.102: v1(109.59,88.1) 109.09,87.61 109.09,86.89 105.83,83.62 CON2.8
  BOTTOM w0.102: U10.58 110.58,89.1 v1(109.59,88.1)
KSI1: length 10.5
  TOP w0.102: v2(105.64,81.48) 106.33,82.16 CON2.7 106.33,83.81 109.57,87.06 v1(109.57,87.47)
  BOTTOM w0.102: v1(109.57,87.47) 110.04,87.94 110.04,88.13 110.98,89.07 U10.59
KSI2: length 8.9
  TOP w0.102: CON2.6 106.83,84 110.04,87.21 110.04,88.05 110.29,88.29 110.8,88.29 v1(110.87,88.36)
  BOTTOM w0.102: U10.60 111.38,88.88 v1(110.87,88.36)
KSI3: length 8.8
  TOP w0.102: CON2.5 107.33,84.21 110.46,87.34 v1(110.46,87.87)
  BOTTOM w0.102: v1(110.46,87.87) 110.53,87.94 111.04,87.94 111.28,88.19 111.28,88.44 111.78,88.94 U10.61
KSI4: length 8.7
  TOP w0.102: CON2.4 107.83,84.42 110.36,86.96 110.66,86.96 111,87.31 v1(111,87.52)
  BOTTOM w0.102: v1(111,87.52) 111.53,88.05 111.53,88.36 112.18,89.01 U10.62
KSI5: length 9.6
  TOP w0.102: CON2.3 108.33,84.61 110.46,86.74 110.82,86.74 111.46,87.38 111.46,87.67 v1(112.2,88.42) 112.8,89.02 v2(112.8,89.12)
  BOTTOM w0.102: U10.63 112.58,88.8 v1(112.2,88.42)
KSI6: length 11.3
  TOP w0.102: v2(115.06,88.97) 114.79,88.7 113.15,88.7 v1(112.85,88.41) 112.43,87.99 112.06,87.99 111.71,87.64 111.71,87.34 110.91,86.54 110.54,86.54 108.83,84.82 CON2.2
  BOTTOM w0.102: U10.64 112.98,88.54 v1(112.85,88.41)
KSI7: length 13.6
  TOP w0.102: CON2.1 109.33,83.81 109.14,84 109.14,84.85 110.63,86.34 111.01,86.34 111.91,87.24 111.91,87.55 112.16,87.79 113.01,87.79 v1(113.5,88.28) 115.07,88.28 115.58,88.79 115.92,88.79 116.17,88.54 116.17,88.54 117.1,88.54 v2(117.58,89.02)
  BOTTOM w0.102: U10.65 113.65,88.13 v1(113.5,88.28)
KSO0: length 12.8
  TOP w0.102: v1(100.06,86.99) 100.06,86.69 97.81,84.43 97.04,84.43 ; v2(95.84,87.55) 96.31,87.07 96.31,85.16 97.04,84.43 ; CON2.26 96.83,84.22 97.04,84.43
  BOTTOM w0.102: v1(100.06,86.99) 101.24,88.16 101.24,88.48 101.78,89.02 U10.36
KSO1: length 10.6
  TOP w0.102: CON2.25 97.33,84.04 97.51,84.23 97.9,84.23 100.11,86.44 100.14,86.44 v1(100.7,87.01) 100.24,87.47 99.72,87.47 v2(99.34,87.09)
  BOTTOM w0.102: U10.37 102.18,89.12 101.44,88.37 101.44,87.75 v1(100.7,87.01)
KSO2: length 11.7
  TOP w0.102: v2(99.72,88.89) 99.72,88.08 100.13,87.67 100.67,87.67 v1(101.33,87.01) 100.57,86.24 100.19,86.24 97.83,83.87 CON2.24
  BOTTOM w0.102: U10.38 102.58,89.12 101.68,88.21 101.68,87.35 v1(101.33,87.01)
KSO3: length 9.7
  TOP w0.102: v1(102.16,88.1) 101.62,88.1 v2(101.3,87.77) 101.75,87.32 101.75,86.83 100.96,86.04 100.28,86.04 98.33,84.08 CON2.23
  BOTTOM w0.102: U10.39 102.98,88.92 v1(102.16,88.1)
KSO4: length 10.2
  TOP w0.102: v2(102.52,89.02) 102.52,88.38 v1(102.79,88.1) 102.37,87.67 102.16,87.67 101.96,87.47 101.96,86.67 101.12,85.83 100.36,85.83 98.83,84.3 CON2.22
  BOTTOM w0.102: U10.40 103.38,89.03 102.79,88.45 v1(102.79,88.1)
KSO5: length 9.9
  TOP w0.102: v2(104.04,87.72) 103.67,88.09 v1(103.43,88.09) 102.76,87.42 102.41,87.42 102.16,87.17 102.16,86.59 101.2,85.63 100.45,85.63 99.33,84.51 CON2.21
  BOTTOM w0.102: U10.41 103.78,89.12 103.43,88.76 v1(103.43,88.09)
KSO6: length 9.1
  TOP w0.102: CON2.20 99.83,84.6 100.63,85.4 101.31,85.4 102.58,86.67 v1(102.58,86.99)
  BOTTOM w0.102: v1(102.58,86.99) 103.26,87.67 103.6,87.67 103.85,87.92 103.85,88.78 104.18,89.12 U10.42
KSO7: length 8.9
  TOP w0.102: CON2.19 100.33,84.71 100.8,85.19 101.42,85.19 v1(103.22,86.99)
  BOTTOM w0.102: v1(103.22,86.99) 103.67,87.44 103.87,87.44 104.05,87.62 104.05,88.58 104.58,89.12 U10.43
KSO8: length 8.9
  TOP w0.102: CON2.18 100.83,83.7 101.25,84.12 101.8,84.12 102.01,84.32 102.01,85.41 103.1,86.5 103.38,86.5 v1(103.86,86.99)
  BOTTOM w0.102: U10.44 104.98,89.12 104.25,88.39 104.25,87.38 v1(103.86,86.99)
KSO9: length 9.8
  TOP w0.102: v2(105.16,89.04) 105.08,88.97 105.08,88.6 v1(104.85,88.37) 104.69,88.2 104.69,87.56 104.29,87.16 104.29,86.71 103.89,86.3 103.18,86.3 102.21,85.33 102.21,84.22 101.88,83.89 101.42,83.89 101.33,83.79 CON2.17
  BOTTOM w0.102: v1(104.85,88.37) 105.38,88.9 U10.45
KSO10: length 10
  TOP w0.102: CON2.16 101.83,83.43 102.41,84.01 102.41,85.2 103.31,86.1 103.97,86.1 104.15,86.27 104.59,86.27 105.8,87.48 106.16,87.48 v2(106.38,87.7) 105.71,88.37 v1(105.49,88.37)
  BOTTOM w0.102: v1(105.49,88.37) 105.78,88.66 U10.46
KSO11: length 10.1
  TOP w0.102: v1(105.91,86.99) 105.91,86.7 105.19,85.98 104.14,85.98 104.06,85.89 103.4,85.89 102.62,85.11 102.62,83.86 102.33,83.57 CON2.15
  BOTTOM w0.102: U10.51 107.78,88.72 107.01,87.95 106.74,87.95 105.91,87.12 v1(105.91,86.99)
KSO12: length 10.3
  TOP w0.102: CON2.14 102.83,85.04 103.48,85.69 104.14,85.69 104.22,85.77 105.66,85.77 106.55,86.66 v1(106.55,86.99)
  BOTTOM w0.102: v1(106.55,86.99) 106.55,87.46 106.83,87.75 107.11,87.75 108.18,88.82 U10.52
KSO13: length 10.6
  TOP w0.102: CON2.13 103.33,83.79 103.03,84.09 103.03,84.93 103.58,85.49 104.23,85.49 104.31,85.57 106.27,85.57 107.1,86.4 v1(107.1,87.3)
  BOTTOM w0.102: v1(107.1,87.3) 107.21,87.42 107.21,87.56 108.58,88.93 U10.53
KSO14: length 10.8
  TOP w0.102: v1(107.66,86.99) 107.66,86.67 106.36,85.37 104.39,85.37 104.31,85.29 103.67,85.29 103.23,84.85 103.23,84.43 103.83,83.84 CON2.12
  BOTTOM w0.102: U10.54 108.98,89.04 107.66,87.72 v1(107.66,86.99)
KSO15: length 11.9
  TOP w0.102: CON2.11 104.33,84.86 104.63,85.16 106.47,85.16 108.22,86.91 v1(108.22,87.3) 108.22,87.69 107.52,88.38 v2(107.52,89.07)
  BOTTOM w0.102: U10.55 109.38,89.1 108.33,88.05 108.33,87.42 v1(108.22,87.3)
KSO16: length 8.1
  TOP w0.102: CON2.10 104.83,83.78 105.92,84.88 106.47,84.88 108.64,87.05 108.64,88.46 T27.1
KSO17: length 9.3
  TOP w0.102: T28.1 110.43,88.52 109.32,88.52 108.84,88.05 108.84,86.96 106.55,84.68 106.05,84.68 105.33,83.95 CON2.9
L_BKLT_CTRL_PCH: length 258.4
  TOP w0.102: GR39.1 167.23,15.74 v1(168.07,16.58) v2(169.09,16.58) ; v1(163.4,43.78) 166.47,40.71 171.7,40.71 174.73,37.68 174.73,37.05 v1(175.85,35.93)
  IN1 w0.102: v1(175.85,35.93) 173.11,35.93 171.58,34.4 171.58,30.65 169.19,28.26 169.19,26.56 168.71,26.08 168.71,17.21 v1(168.07,16.58)
  IN2 w0.102: v1(19.52,63.09) 19.55,63.12 19.55,68.01 18.07,69.49 17.05,69.49 16.51,70.03 16.51,73.64 15.98,74.17 15.98,76.21 18.27,78.5 19.33,78.5 22.2,81.37 24.22,81.37 26.56,83.71 31.45,83.71 31.6,83.86 37.09,83.86 38.17,84.95 40.14,84.95 40.8,84.29 46.63,84.29 47.27,84.93 51.36,84.93 51.87,84.42 55.65,84.42 55.89,84.18 61.4,84.18 61.7,84.49 65.14,84.49 65.64,84.98 77.46,84.98 78,85.51 83.39,85.51 83.57,85.34 83.57,84.72 84.19,84.09 85.35,84.09 85.89,83.56 87.78,83.56 88.36,84.13 93.2,84.13 93.95,84.88 96.08,84.88 96.78,84.18 105.59,84.18 106.66,85.25 112.7,85.25 114.77,83.18 120.16,83.18 120.6,83.62 130.2,83.62 130.48,83.9 132.97,83.9 133.23,83.63 137.17,83.63 137.73,84.19 139.85,84.19 140.62,83.43 142.93,83.43 145.48,80.88 155.56,80.88 157.35,79.09 164.2,79.09 167.12,76.17 167.12,70.56 165.91,69.35 165.91,59.99 163.09,57.17 163.09,45.2 162.98,45.09 162.98,44.2 v1(163.4,43.78)
  BOTTOM w0.089: U1.B8 20.09,62.91 19.92,63.09 v1(19.52,63.09)
L_VDDEN_PCH: length 115.1
  TOP w0.089: v2(22.3,64.23) 22.3,64.3 v1(22.79,64.79)
  IN2 w0.089: v1(22.79,64.79) 23.2,65.2 23.2,66.95 23.39,67.14 23.39,70.58 23.04,70.93
  IN2 w0.102: v1(112.29,82.65) 111.86,83.08 111.19,83.08 110.5,83.76 106.04,83.76 105.84,83.57 96.51,83.57 96.45,83.63 94.15,83.63 93.83,83.32 89.68,83.32 89.24,82.88 85.8,82.88 85.73,82.81 82.37,82.81 82.11,83.07 82.11,84.11 81.77,84.45 67.64,84.45 66.6,83.41 62.97,83.41 62.19,82.63 55.72,82.63 55.29,83.06 49.01,83.06 48.66,82.72 44.86,82.72 43.75,81.61 42.04,81.61 40.95,82.7 40.06,82.7 38.58,81.22 35.77,81.22 35.52,81.48 33.46,81.48 32.54,80.56 28.96,80.56 27.71,79.31 25.62,79.31 23.64,77.33 22.75,77.33 21.43,76.01 21.43,72.55 23.04,70.93
  BOTTOM w0.089: U1.C6 22.46,64.03 22.79,64.36 v1(22.79,64.79)
  BOTTOM w0.102: U10.79 113.41,82.53 113.3,82.65 v1(112.29,82.65)
LAD0: length 161.4
  TOP w0.089: 48.35,54.86 45.64,54.86 45.34,55.16 44.12,55.16 43.42,55.86 43.42,56.9 42.55,57.77 42.55,59.73 42.31,59.96 40.94,59.96 v1(40.72,59.74)
  TOP w0.102: v2(130.3,28.31) 130.3,29.69 130.81,30.19 v1(130.81,30.45) R166.2 ; R178.1 94.57,78.97 94.57,78.18 93.59,77.21 93.42,77.21 93.01,76.8 92.28,76.8 91.21,75.72 90.7,75.72 90.38,75.4 90.38,75.26 v1(90.27,75.15) ; 48.35,54.86 48.41,54.92 51.97,54.92 52.68,55.63 52.68,57.28 54.67,59.27 56.34,59.27 57.51,60.44 57.51,60.97 57.93,61.39 57.93,70.07 58.94,71.08 58.94,72.05 60.49,73.59 62.69,73.59 62.94,73.84 64.72,73.84 64.8,73.76 66.44,73.76 67.83,75.15 76.93,75.15 77.68,74.4 79.46,74.4 v1(80.96,75.9)
  IN1 w0.127: v1(90.27,75.15) 90.38,75.26 90.38,75.36 90.75,75.73 91.1,75.73 92.18,76.82 92.83,76.82 93.85,75.8 93.85,74.28 96.06,72.07 96.06,69.9 97.92,68.04 97.92,63.74 96.07,61.89 96.07,48.77 95.09,47.79 95.09,46.39 97.35,44.14 98.11,44.14 109.51,32.74 128.51,32.74 v1(130.81,30.45)
  IN3 w0.102: v1(80.96,75.9) 81.36,76.3 82.48,76.3 83.03,75.74 89.22,75.74 89.81,75.15 v1(90.27,75.15)
  BOTTOM w0.089: v1(40.72,59.74) 40.72,59.75 40.94,59.97 U1.AU14
LAD0_EC: length 30.4
  TOP w0.102: v1(88.19,80.41) 87.87,80.09 87.87,78.48 88.96,77.4 CON5.2 ; R178.2 97.05,78.47 97.05,77.92 97.3,77.67 98.08,77.67 v2(99.39,78.99) 99.72,78.66 100.74,78.66 v1(101.16,78.24)
  IN1 w0.127: v1(88.19,80.41) 88.44,80.66 92.01,80.66 92.85,81.5 94.02,81.5 96.1,79.42 96.1,78.46 97.18,77.38 99.31,77.38 99.62,77.69 100.79,77.69 101.16,78.06 v1(101.16,78.24)
  BOTTOM w0.102: U10.10 100.14,79.33 101.16,78.31 v1(101.16,78.24)
