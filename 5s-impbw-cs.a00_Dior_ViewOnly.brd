# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_MAA7: length 40
  TOP w0.165: v1(66.31,44.74) 66.08,44.98 66.02,44.98 65.71,45.28 63.58,45.28 63.07,44.77 63.07,44.34 62.6,43.87 60.74,43.87 59.91,43.04 59.36,43.04 58.88,42.56 58.88,41.95 59.29,41.55 59.29,41.25 58.93,40.89 58.8,40.89 58.58,41.11 58.35,41.11 58.12,40.89 57.16,40.89 56.67,40.4 56.67,39.46 56.54,39.34 56.19,39.34 56.03,39.49 56.03,40.1 55.88,40.25 55.5,40.25 55.37,40.12 55.37,39.51 55.2,39.34 54.89,39.34 54.72,39.5 54.72,40.14 54.56,40.3 54.23,40.3 54.06,40.14 v2(54.06,39.82) 54.06,39.5 53.9,39.34 53.57,39.34 53.4,39.5 53.4,40.14 53.24,40.3 52.91,40.3 52.74,40.14 52.74,39.5 52.58,39.34 52.25,39.34 52.08,39.5 52.08,40.14 51.92,40.3 51.59,40.3 51.42,40.14 51.42,39.5 51.26,39.34 50.93,39.34 50.76,39.5 50.76,40.14 50.6,40.3 50.27,40.3 50.1,40.14 50.1,39.5 49.94,39.34 49.64,39.34 49.47,39.51 49.47,40.03 48.29,41.22 47.8,41.22 47.7,41.11 47.7,40.86 47.58,40.73 47.17,40.73 47.06,40.85 47.06,41.2 46.92,41.34 46.37,41.34 46.2,41.17 46.2,40.89 45.9,40.58 45.65,40.58 45.24,40.17 v1(45.04,40.17)
  BOTTOM w0.089: U1.AY46 43.82,39.91 43.95,39.77 44.39,39.77 44.79,40.17 v1(45.04,40.17)
  BOTTOM w0.165: DIMM1.86 66.32,44.75 v1(66.31,44.74)
M_CHB_MAA8: length 40.3
  TOP w0.089: 45.84,41.17 45.33,40.66 44.96,40.66 44.64,40.34 44.64,40.08 44.33,39.77 44,39.77 v1(43.68,39.45)
  TOP w0.165: v1(62.23,44.74) 62.23,44.49 62.03,44.29 60.56,44.29 59.73,43.46 59.19,43.46 58.45,42.72 58.45,41.84 58.03,41.42 58.02,41.42 58.01,41.41 56.94,41.41 v2(56.92,41.39) 56.29,40.76 49.35,40.76 48.44,41.67 46.34,41.67 45.84,41.17
  BOTTOM w0.089: U1.AY47 43.31,39.08 v1(43.68,39.45)
  BOTTOM w0.165: v1(62.23,44.74) 63.07,45.58 63.07,46.6 63.15,46.68 63.43,46.68 63.6,46.85 63.6,47.06 63.04,47.62 63.04,48.04 63.24,48.23 63.48,48.23 64.11,47.59 64.34,47.59 64.87,48.12 65.11,48.12 65.28,48.29 65.28,48.7 65.14,48.84 64.57,48.84 64.42,48.99 64.42,49.42 64.26,49.57 63.83,49.57 63.65,49.4 63.65,49.09 63.45,48.89 62.64,48.89 62.36,48.61 62.36,47.39 62.13,47.16 62.13,46.68 62.33,46.47 62.33,46.14 61.84,45.65 DIMM1.89
M_CHB_MAA9: length 41.9
  TOP w0.165: v1(44.17,40.17) 43.99,40.35 43.99,40.53 44.2,40.73 44.45,40.73 44.88,41.17 45.06,41.17 45.16,41.06 45.27,41.06 45.59,41.38 45.59,41.52 45.47,41.65 45.47,41.83 45.73,42.09 48.22,42.09 48.36,42.23 48.36,42.52 48.52,42.67 48.94,42.67 49.07,42.54 49.07,41.63 49.3,41.4 49.61,41.4 49.79,41.58 49.79,42.54 49.92,42.67 50.27,42.67 50.44,42.5 50.44,41.39 50.61,41.23 50.94,41.23 51.1,41.39 51.1,42.5 51.27,42.67 51.6,42.67 51.76,42.5 51.76,41.39 51.93,41.23 52.26,41.23 52.42,41.39 52.42,42.5 52.59,42.67 52.92,42.67 53.08,42.5 53.08,41.39 53.25,41.23 53.58,41.23 53.74,41.39 53.74,42.5 53.91,42.67 54.24,42.67 54.4,42.5 54.4,41.34 54.57,41.18 54.9,41.18 55.06,41.34 v2(55.06,41.88) 55.06,42.5 55.23,42.67 55.56,42.67 55.72,42.5 55.72,41.39 55.89,41.23 56.16,41.23 56.38,41.45 56.38,42.4 56.49,42.51 56.69,42.51 57.38,41.83 57.84,41.83 58.02,42 58.02,42.42 57.9,42.54 57.51,42.54 57.18,42.87 57.18,43.08 57.56,43.46 57.94,43.46 58.15,43.25 58.38,43.25 59.01,43.88 59.56,43.88 60.42,44.74 v1(60.93,44.74)
  BOTTOM w0.089: v1(44.17,40.17) 44.08,40.09 43.49,40.09 43.38,40.19 41.98,40.19 41.97,40.21 41.72,40.21 41.47,39.96 U1.AU46
  BOTTOM w0.165: v1(60.93,44.74) 60.64,44.45 DIMM1.85
M_CHB_MAA10: length 45.2
  TOP w0.089: v1(37.1,46.66) 37.47,47.03 37.91,47.03 37.92,47.03 38.81,47.03 39.01,47.23 39.01,47.86 39.31,48.16 40.72,48.16 41.12,48.56
  TOP w0.165: 41.12,48.56 41.12,49.04 41.33,49.24 41.8,49.24 41.93,49.37 41.93,49.74 42.09,49.9 42.47,49.9 42.64,49.74 42.64,49.27 42.77,49.14 43.23,49.14 43.38,49.29 43.94,49.29 44.12,49.12 44.33,49.12 44.65,49.45 44.65,49.74 45.83,50.92 46.46,50.92 46.64,50.74 47.04,50.74 47.22,50.92 48.04,50.92 48.2,50.75 48.2,50.53 48.37,50.37 48.7,50.37 48.86,50.53 48.86,50.75 49.03,50.92 49.36,50.92 49.52,50.75 49.52,50.53 49.69,50.37 50.02,50.37 50.18,50.53 50.18,50.75 50.35,50.92 50.68,50.92 50.84,50.75 50.84,50.53 51.01,50.37 51.34,50.37 51.51,50.53 51.51,50.88 51.67,51.05 52,51.05 52.17,50.88 52.17,50.53 52.33,50.37 52.66,50.37 52.83,50.53 52.83,50.86 52.99,51.02 53.32,51.02 v2(53.52,50.82) 53.65,50.69 53.88,50.69 54.03,50.84 54.03,51.15 54.15,51.27 54.51,51.27 54.68,51.45 59.11,51.45 59.45,51.1 59.88,51.1 60.23,51.45 62.94,51.45 63.15,51.65 v1(63.15,51.91)
  BOTTOM w0.089: v1(37.1,46.66) 36.78,46.35 U1.AK36
  BOTTOM w0.165: DIMM1.107 60.38,51.05 60.68,50.75 61.11,50.75 61.24,50.87 61.8,50.87 63.02,49.65 63.31,49.65 63.97,50.31 64.17,50.31 64.68,49.8 64.95,49.8 65.22,50.07 65.22,50.26 63.44,52.04 63.27,52.04 v1(63.15,51.91)
M_CHB_MAA11: length 41.1
  TOP w0.089: v1(44.28,39.34) 44.29,39.34 44.7,39.74 45.31,39.74 45.78,40.22
  TOP w0.165: 45.78,40.22 46.17,40.22 46.31,40.35 46.31,40.58 46.43,40.71 46.69,40.71 46.99,40.4 48.46,40.4 49.05,39.82 49.05,39.34 49.47,38.92 56.89,38.92 57.33,39.36 57.33,39.67 57.1,39.9 57.1,40.2 57.37,40.47 57.66,40.47 57.99,40.15 58.12,40.15 58.45,40.47 59.11,40.47 59.86,41.22 59.86,41.58 59.31,42.13 59.31,42.38 59.51,42.59 59.79,42.59 60.14,42.24 60.4,42.24 60.61,42.44 60.61,43.15 60.91,43.46 62.07,43.46 62.23,43.29 62.23,42.82 62.43,42.61 62.76,42.61 62.87,42.71 62.87,43.45 62.97,43.55 63.4,43.55 63.57,43.39 63.57,42.59 63.67,42.49 64.06,42.49 64.19,42.61 64.19,43.58 v2(63.93,43.83) 63.5,44.26 63.5,44.57 63.78,44.85 64.11,44.85 64.29,44.67 64.29,44.42 64.83,43.87 65.64,43.87 65.99,44.22 65.99,44.36 v1(65.6,44.74)
  BOTTOM w0.089: U1.AV47 42.13,38.8 43.74,38.8 v1(44.28,39.34)
  BOTTOM w0.165: v1(65.6,44.74) 65.36,44.5 65.36,44.31 65.52,44.15 DIMM1.84
M_CHB_MAA12: length 38.4
  TOP w0.089: v1(41.53,39.5) 41.98,39.05 43.37,39.05 43.59,38.83 45.4,38.83
  TOP w0.165: v1(61.72,43) 61.72,42.73 62.26,42.19 62.5,42.19 v2(62.61,42.08) 62.61,41.29 62.09,40.77 60.59,40.77 59.45,39.63 58.79,39.63 57.24,38.08 49.06,38.08 48.21,38.93 48.21,39.39 48.03,39.57 47.3,39.57 47.19,39.46 47.19,39.18 47.04,39.03 46.84,39.03 46.43,39.44 46.01,39.44 45.4,38.83
  BOTTOM w0.089: U1.AU47 41.53,39.37 v1(41.53,39.5)
  BOTTOM w0.165: DIMM1.83 60.73,43.85 61.11,44.24 62.71,44.24 63.55,45.08 63.55,45.94 63.68,46.07 64.47,46.07 64.59,45.94 64.59,44.95 62.96,43.31 62.03,43.31 v1(61.72,43)
M_CHB_MAA13: length 47.2
  TOP w0.089: v1(36.49,48.55) 36.88,48.16 38.03,48.16 38.06,48.18 38.58,48.18 38.84,48.44 38.84,48.86 39.33,49.36 39.62,49.36 40.24,49.98 40.71,49.98 41.85,51.12 41.98,51.12
  TOP w0.165: 41.98,51.12 42.15,51.28 42.15,51.28 43.11,52.24 44.3,52.24 44.47,52.41 47.65,52.41 47.86,52.2 48.85,52.2 48.97,52.32 53.08,52.32 53.29,52.53 53.91,52.53 54.59,53.22 v2(57.18,53.22) 58.34,53.22 58.6,53.47 58.96,53.47 59.65,54.16 60.21,54.16 60.81,53.56 62.24,53.56 62.48,53.8 62.82,53.8 63.23,53.4 65.28,53.4 65.52,53.64 66.5,53.64 67.95,55.08 67.95,55.64 67.21,56.37 66.64,56.37 66.47,56.37 66.06,55.97 66.06,55.52 65.8,55.26 64.87,55.26 64.5,54.89 64.04,54.89 63.89,55.04 v1(63.88,55.03)
  BOTTOM w0.089: v1(36.49,48.55) 36.49,48.37 U1.AK33
  BOTTOM w0.165: v1(63.88,55.03) 63.32,55.59 62.16,55.59 61.85,55.29 61.42,55.29 60.78,54.65 DIMM1.119
M_CHB_MAA14: length 43
  TOP w0.089: v1(40.59,40.08) 40.59,39.59 41.35,38.83 43.06,38.83 43.31,38.57 45.65,38.57
  TOP w0.165: v1(66.31,43) 66.34,43 66.97,43.64 v2(66.97,44.14) 66.85,44.26 66.63,44.26 65.82,43.46 64.78,43.46 64.62,43.3 64.62,42.79 65.03,42.38 65.61,42.38 66.14,41.85 66.14,41.72 66.02,41.6 65.51,41.6 65.3,41.39 65.3,40.81 65.41,40.71 65.71,40.71 65.88,40.54 65.88,40.03 65.74,39.9 64.72,39.9 64.64,39.97 64.64,41.65 64.26,42.03 63.35,42.03 63.07,41.75 63.07,41.11 62.28,40.33 60.74,40.33 59.63,39.22 58.97,39.22 57.41,37.66 48.85,37.66 48.08,38.42 47.47,38.42 47.09,38.04 46.81,38.04 46.64,38.22 46.64,38.65 46.41,38.88 45.95,38.88 45.65,38.57
  BOTTOM w0.089: U1.AR46 40.52,40 v1(40.59,40.08)
  BOTTOM w0.165: DIMM1.80 66.37,42.95 v1(66.31,43)
M_CHB_MAA15: length 43
  TOP w0.089: v1(38.36,39.39) 39.11,39.39 39.66,39.93 39.99,39.93 41.35,38.57 42.93,38.57
  TOP w0.165: 42.93,38.57 43.18,38.32 46,38.32 46.69,37.63 47.22,37.63 47.55,37.96 47.86,37.96 48.06,37.77 48.06,37.49 v2(48.31,37.24) 57.58,37.24 59.14,38.8 59.8,38.8 60.9,39.9 62.51,39.9 62.82,40.2 63.27,40.2 63.55,40.48 63.55,41.48 63.68,41.61 64.05,41.61 64.23,41.43 64.23,39.68 64.43,39.48 65.92,39.48 66.3,39.86 66.3,40.81 66.73,41.24 66.73,42.11 66.28,42.55 66.08,42.55 65.68,42.95 v1(65.68,43)
  BOTTOM w0.089: U1.AP46 39.23,40 38.61,39.39 v1(38.36,39.39)
  BOTTOM w0.165: v1(65.68,43) 65.7,43 65.52,42.82 65.52,42.82 65.28,42.58 65.28,42.31 65.71,41.88 65.99,41.88 66.46,42.35 DIMM1.78
M_CHB_ODT0: length 13.1
  TOP w0.165: HR15.2 63.22,63.27 63.22,61.89 65.08,60.04 v2(65.08,59.5) 65.08,59.15 64.26,58.33 64.26,57.56 64.48,57.34 64.48,57.01 65.38,56.1 65.38,55.96 65.39,55.96 v1(65.39,55.95)
  BOTTOM w0.165: DIMM1.116 66.79,53.75 65.39,55.15 v1(65.39,55.95)
M_CHB_ODT1: length 12.5
  TOP w0.165: v1(64.75,56.08) 63.91,56.91 63.91,59.45 63.43,59.94 v2(63.43,60.32) 63.43,60.95 62.82,61.56 62.82,63.38 HR14.2
  BOTTOM w0.165: v1(64.75,56.08) 65.1,56.43 65.23,56.43 65.25,56.41 65.91,56.41 66.5,55.82 66.5,55.29 66.84,54.95 DIMM1.120
M_CHB_RAS#: length 45.8
  TOP w0.089: v1(38.41,46.63) 38.73,46.63 39.19,47.08 39.19,47.79 39.38,47.98 40.98,47.98 41.23,48.23
  TOP w0.165: 41.23,48.23 41.63,48.23 41.76,48.35 41.76,48.66 41.94,48.84 42.34,48.84 42.55,48.63 42.55,48.33 42.67,48.2 43.13,48.2 43.26,48.33 43.26,48.66 43.41,48.81 43.84,48.81 44.1,48.56 44.45,48.56 45.09,49.19 45.09,49.57 45.32,49.8 45.65,49.8 45.85,50 45.85,50.3 46.02,50.46 46.35,50.46 46.51,50.3 46.51,50.15 46.72,49.95 47.01,49.95 47.17,50.11 47.17,50.3 47.34,50.46 47.67,50.46 47.83,50.3 47.83,50.1 47.99,49.95 52.88,49.95 53.19,50.26 53.51,50.26 53.79,49.98 54.01,49.98 54.43,50.4 54.43,50.61 54.85,51.03 58.93,51.03 59.29,50.66 60.04,50.66 60.4,51.03 63.69,51.03 64.64,51.99 64.64,52.65 64.72,52.72 v2(65.08,52.72) 65.46,52.72 65.84,53.1 66.57,53.1 66.83,52.85 66.83,52.13 66.58,51.88 65.99,51.88 v1(65.89,51.99)
  BOTTOM w0.089: U1.AM35 38.08,46.97 38.41,46.64 v1(38.41,46.63)
  BOTTOM w0.165: v1(65.89,51.99) 65.89,51.98 65.46,52.42 65.46,52.54 64.06,53.94 64.06,54.25 64.24,54.42 64.61,54.42 66.23,52.8 66.23,52.55 66.83,51.95 DIMM1.110
M_CHB_WE#: length 45.2
  TOP w0.089: 41.58,49.73 41.48,49.62 40.39,49.62 39.77,49 39.51,49 39.22,48.71 39.22,48.32 38.83,47.93 38.83,47.31 38.73,47.21 37.99,47.21 37.99,47.21 37.39,47.21 37.34,47.15 37.02,47.15 36.58,46.71 v1(36.58,45.74)
  TOP w0.165: v1(61.7,51.91) 62.04,52.25 62.04,52.58 61.93,52.7 61.16,52.7 61.01,52.54 61.01,51.99 60.89,51.87 60.4,51.87 60.3,51.96 v2(60.3,52.42) 60.3,52.87 60.12,53.05 59.78,53.05 59.59,52.86 59.59,52.06 59.39,51.87 58.52,51.87 58.42,51.96 58.42,52.11 58.17,52.36 57.73,52.36 57.23,51.87 54.43,51.87 54.25,51.69 53.64,51.69 53.42,51.48 51.47,51.48 51.36,51.36 45.73,51.36 44.65,50.28 43.82,50.28 43.59,50.05 43.59,49.8 43.46,49.67 43.11,49.67 43,49.78 43,50.11 42.83,50.28 41.78,50.28 41.58,50.08 41.58,49.73
  BOTTOM w0.089: U1.AK35 36.6,46.9 36.6,46.49 36.47,46.35 36.47,45.85 v1(36.58,45.74)
  BOTTOM w0.165: DIMM1.113 60.4,52.85 60.56,52.7 61.37,52.7 62.32,53.65 62.32,54.19 62.06,54.45 62.06,54.86 62.37,55.17 62.84,55.17 63.04,54.97 63.04,53.26 v1(61.7,51.91)
MAG_DRDY_IO: length 35.6
  TOP w0.102: U17.7 160.45,83.15 v1(160.22,82.92) 160.22,82.82 159.74,82.34 158.32,82.34 157.51,81.53 157.51,80.29 158.56,79.24 160.45,79.24 162,77.69 v2(162,77) 162,75.51 163.48,74.03 v1(163.48,73.5)
  IN1 w0.102: v1(172.42,83.2) 171.76,82.54 170.13,82.54 168.54,84.13 161.46,84.13 160.25,82.92 v1(160.22,82.92)
  BOTTOM w0.102: R360.2 175.08,83.7 175.08,83.51 174.78,83.2 v1(172.42,83.2) ; v1(163.48,73.5) 162.51,72.53 162.51,71.9 162.42,71.81 U20.32
MAG_DRDY_IO_R: length 11.3
  TOP w0.102: v2(173.59,84.52) 174.47,83.63 v1(174.6,83.63)
  BOTTOM w0.102: CON11.8 180.25,85.33 179.94,85.64 178.72,85.64 177.7,86.66 175.97,86.66 175.34,86.02 R360.1 174.72,84.17 C185.1 174.51,83.63 v1(174.6,83.63)
MEM_ID0: length 8
  BOTTOM w0.089: 27.13,70.65 v2(27.26,70.53) 27.26,70.1 27.25,70.1 27.25,68.99 27.26,68.98 27.26,68.98 27.45,68.79 27.45,67.33 27.33,67.21 27.33,67.02 27.02,66.71 U1.L3
  BOTTOM w0.102: 27.13,70.65 26.82,70.96 26.82,71.13 R96.1 26.01,71.94 26.01,73.21 R92.2
MEM_ID1: length 24.1
  TOP w0.102: R93.2 15.42,74.99 15.42,73.46 R97.1 15.84,72.24 v2(15.52,71.92) 16.49,70.96 v1(17.96,70.96)
  IN2 w0.089: 17.98,70.93 19.94,68.98 19.94,68.65 21.6,66.99 21.6,64.27 22.58,63.29 25.78,63.29 26.13,62.94 27.25,62.94 27.76,63.46 27.76,64.32 v1(28.23,64.79)
  IN2 w0.102: 17.98,70.93 v1(17.96,70.96)
  BOTTOM w0.089: U1.R5 28.61,65.17 v1(28.23,64.79)
MEM_ID2: length 19.3
  TOP w0.102: v1(17.92,71.62) 17.72,71.82 17.5,71.82 v2(17.25,72.08) 16.67,72.65 R98.1 17.17,73.54 17.17,74.92 R94.2
  IN2 w0.089: v1(26.39,65.38) 24.14,65.38 23.12,64.36 22.24,64.36 21.78,64.81 21.78,67.06 20.5,68.34 20.5,69.04 18.61,70.93
  IN2 w0.102: 18.61,70.93 v1(17.92,71.62)
  BOTTOM w0.089: v1(26.39,65.38) 26.86,65.85 U1.L4
MSATA_DISABLE: length 143.7
  TOP w0.102: v1(102.31,35.3) 96.42,35.3 v2(96.39,35.27) 91.8,35.27 v1(91.44,35.63) ; SR21.1 23.08,71.74 23.08,72.54 23.29,72.76 23.29,73.5 SR16.2 22.48,74.31 22.48,75.08 22.91,75.51 22.91,75.99 23.37,76.45 SR85.2 23.38,75.9 v1(23.57,75.71)
  IN2 w0.102: v1(81.48,83.8) 81.03,83.34 80,83.34 79.3,84.04 67.85,84.04 66.81,83 63.14,83 62.36,82.22 55.55,82.22 55.12,82.65 49.18,82.65 48.83,82.31 45.03,82.31 43.89,81.17 41.91,81.17 40.78,82.3 40.23,82.3 38.67,80.73 38.25,80.73 37.92,80.4 37.05,80.4 36.9,80.26 33.69,80.26 32.39,78.95 28.92,78.95 25.72,75.75 25.72,75.42 25.17,74.87 24.08,74.87 23.57,75.38 v1(23.57,75.71)
  BOTTOM w0.102: CONSATA.8 102.69,30.58 101.98,31.28 101.98,32.38 102.29,32.68 102.29,35.27 v1(102.31,35.3) ; v1(91.44,35.63) 90.53,35.63 90.27,35.88 90.27,40.25 91.47,41.44 91.47,50.31 91.15,50.63 91.15,64.71 90.04,65.82 90.04,68.2 88.38,69.86 88.38,72.76 86.75,74.39 84.49,74.39 81.33,77.55 81.33,83.65 v1(81.48,83.8)
MSATA_RST#: length 90.2
  TOP w0.102: v1(93.96,33.77) 94.74,32.99 v2(98.05,32.99) 98.3,32.99 99.57,31.72 v1(101.5,31.72)
  IN3 w0.102: v1(90.54,73.07) 90.92,73.46 94.02,73.46 96.32,75.76 98.08,75.76 99.93,77.61 102.46,77.61 102.72,77.36 109.85,77.36 v1(110.33,77.84)
  BOTTOM w0.102: U10.104 110.18,77.7 v1(110.33,77.84) ; v1(93.96,33.77) 92.36,35.37 92.36,36.19 91.31,37.23 91.31,39.69 92.43,40.81 92.43,67.28 92.6,67.45 92.6,70.19 92.36,70.43 92.36,70.95 90.54,72.78 v1(90.54,73.07) ; v1(101.5,31.72) 101.5,31.21 102.67,30.04 102.67,29.76 104.93,27.5 104.93,20.2 104.81,20.08 CONSATA.50
Net_1445: length 0.3
  BOTTOM w0.203: 20.51,55.53 20.51,55.82
Net_1447: length 0.3
  BOTTOM w0.203: 20.51,54.62 20.51,54.33
Net_1448: length 0.3
  BOTTOM w0.203: 20.51,49.46 20.51,49.16
Net_1498: length 0.3
  BOTTOM w0.203: 43.14,46.21 42.85,46.28
NGFF_PCIE_WAKE#: length 103.9
  TOP w0.102: R307.1 177.45,57.55 v1(177.24,57.75) ; R175.2 104,81.35 R184.1 104.52,79.82 v2(105.18,79.16) 105.27,79.07 v1(105.27,77.78)
  IN1 w0.102: v1(105.27,77.78) 105.5,77.55 108.73,77.55 111.98,74.3 115.35,74.3 118.39,71.26 124.51,71.26 127.08,73.83 140.87,73.83 141.43,74.39 144.11,74.39 147.93,70.57 147.93,67.68 148.68,66.93 152.87,66.93 154.74,68.8 161.22,68.8 163.3,70.88 164.21,70.88 165.51,72.18 166.63,72.18 167.9,70.91 169.62,70.91 170.18,71.47 175.06,71.47 180.11,66.41 180.11,62.81 177.55,60.24 177.55,58.06 v1(177.24,57.75)
NGFF_PCIE_WAKE#_EC: length 15.4
  TOP w0.102: R184.2 104.23,81.67 v1(103.56,82.34) 103.55,82.34 103.13,81.91 101.55,81.91 v2(101.2,81.55)
  BOTTOM w0.102: v1(103.56,82.34) 103.56,82.97 104.52,83.94 104.52,85.24 105.38,86.1 107.67,86.1 108.89,87.32 108.89,88.32 109.45,88.88 109.67,88.88 109.78,89 U10.56
OC0#: length 70.3
  TOP w0.102: v1(6.06,83.05) 5.81,83.3 v2(5.06,83.3)
  IN1 w0.102: v1(6.06,83.05) 5.87,82.86 5.87,82.16 4.84,81.13 4.84,79.02 4.61,78.79 4.61,76.04 5.95,74.69 6.83,74.69 7.33,75.19 9.96,75.19 10.43,75.66 11,75.66 12.04,76.7 15.05,76.7 16.03,77.68 17.88,77.68 21.16,80.96 23.72,80.96 24.44,81.68 28.3,81.68 28.65,81.32 29.06,81.32 29.36,81.63 29.36,81.87 30.27,82.77 35.37,82.77 36.04,82.1 36.04,81.58 36.4,81.22 36.86,81.22 37.31,80.76 39.4,80.76 40.39,79.77 40.39,78.85 41.5,77.75 41.5,74.63 41.25,74.39 41.06,74.39 v1(40.03,73.36)
  BOTTOM w0.089: 37.5,68.93 37.5,68.37 37.19,68.07 37.19,67.67 37.35,67.51 37.54,67.51 37.76,67.28 37.76,67.02 37.51,66.77 U1.AL3
  BOTTOM w0.102: v1(40.03,73.36) 40.54,72.85 40.54,72.14 40.03,71.63 40.03,71.29 39.27,70.53 38.7,70.53 37.5,69.33 37.5,68.93 ; v1(6.06,83.05) 6.33,83.05 6.81,82.57 6.81,81.9 6.96,81.74 CON10.16
OC1#: length 67.4
  TOP w0.102: v2(5.13,81.53) 5.41,81.53 6.01,82.12 v1(6.3,82.12)
  IN1 w0.089: v1(40.47,68.53) 39.93,69.06 39.93,70.45
  IN1 w0.102: 39.93,70.45 40.54,71.06 40.54,73.37 44.27,77.11 44.98,77.11 45.42,76.67 45.98,76.67 46.38,77.08 46.38,80.54 45.8,81.12 45.8,81.39 42.68,84.51 40.76,84.51 40.36,84.1 37.53,84.1 36.73,84.9 34.09,84.9 31.58,87.41 26.03,87.41 23.83,85.21 22.85,85.21 22.14,84.5 19.23,84.5 18.4,83.67 18.4,83.11 17.96,82.67 15.47,82.67 14.54,81.74 6.68,81.74 v1(6.3,82.12)
  BOTTOM w0.089: v1(40.47,68.53) 40.51,68.48 U1.AT1
  BOTTOM w0.102: CON10.17 6.84,81.24 6.3,81.78 v1(6.3,82.12)
OC2#: length 172.4
  TOP w0.102: v1(144.93,74.85) 146.67,76.59 v2(147.17,76.59) 149.31,76.59 150.08,77.35 v1(150.08,83.2)
  IN1 w0.102: v1(150.08,83.2) 150.78,83.89 150.78,86 152.59,87.81 167.22,87.81 168.68,86.35 173.41,86.35 v1(174.07,85.69)
  IN2 w0.089: 44.83,70.93 44.83,68.7 43.48,67.35 38.38,67.35 36.31,69.42 v1(36.23,69.42)
  IN2 w0.102: v1(144.93,74.85) 144.72,75.06 141.61,75.06 140.78,74.24 122.14,74.24 121.36,73.46 114.45,73.46 113.21,74.7 113.21,75.54 112.72,76.03 111.56,76.03 110.33,74.79 100.59,74.79 100.21,75.18 96.15,75.18 95.65,75.68 91.78,75.68 91.4,75.31 91.4,75.16 91.09,74.85 90.58,74.85 90.31,74.58 89.3,74.58 88.83,74.11 77.12,74.11 76.28,74.95 68.2,74.95 66.96,73.71 64.47,73.71 64.03,73.27 57.91,73.27 57.49,73.69 53.18,73.69 52.73,73.23 46.38,73.23 44.83,71.69 44.83,70.93
  BOTTOM w0.089: 35.83,69.01 35.83,68.24 35.69,68.09 35.69,67.44 U1.AH2
  BOTTOM w0.102: v1(174.07,85.69) 173.98,85.78 C181.1 175.03,86.33 175.77,87.06 177.95,87.06 178.12,86.9 179.87,86.9 180.19,86.58 181.34,86.58 182.25,85.67 CON11.12 ; v1(36.23,69.42) 36.23,69.41 35.83,69.01
OC3#: length 7.6
  BOTTOM w0.089: 44.63,70.65 44.63,70.17 43.72,69.26 43.72,68.74 43.92,68.55 43.92,66.76 43.37,66.21 42.93,66.21 42.86,66.13 42.17,66.13 U1.AV3
  BOTTOM w0.102: 44.63,70.65 R109.2
OS_11: length 12.9
  TOP w0.178: U13.4 21.8,84.79 21.69,84.67 21.69,84.29 21.52,84.12 21.52,82.87 21.89,82.5 21.89,81.17 21.75,81.02 20.18,81.02 19.43,80.27 v2(19.01,80.27) 18.42,80.87 18.42,82.41 19.43,83.43 19.43,83.94 19.75,84.26 R323.2
OS_12: length 2.5
  TOP w0.254: U13.15 26.28,84.79 26.54,84.52 26.54,84.36 26.87,84.03 26.87,83.45 R326.2
OS_21: length 2.5
  TOP w0.254: U14.4 32.52,83.16 31.85,82.5 31.85,81.96 31.71,81.81 R331.2
OS_22: length 2.6
  TOP w0.254: R334.2 38.96,83.02 38.15,83.02 v2(38.03,82.9) 37.76,83.16 U14.15
PANEL_BIST_ON: length 134.1
  TOP w0.102: v1(186.96,30.7) 186.96,31.02 v2(186.51,31.46)
  IN1 w0.102: v1(144.82,83.21) 144.24,83.79 127.31,83.79 126.72,83.2 113.87,83.2 v1(113.25,83.82)
  IN3 w0.102: v1(177.88,32.35) 177.88,34.37 v1(181.4,37.9) 182.3,37 182.3,35.91 186.96,31.25 v1(186.96,30.7) ; v1(144.82,83.21) 145.44,83.82 157.35,83.82 158.9,82.28 163.97,82.28 168.12,78.12 168.12,73.14 167.49,72.51 167.49,49.18 169.22,47.45 169.22,44.47 169.66,44.04 169.66,43.44 v1(169.24,43.02)
  BOTTOM w0.102: U10.77 113.74,83.33 113.25,83.82 v1(113.25,83.82) ; VU3.1 v1(181.4,37.9) ; v1(177.88,32.35) 177.53,32.01 174.99,32.01 174.42,32.58 VU4.1 173.73,35.99 173.41,36.31 173.41,39.62 171.02,42.01 171.02,42.6 170.18,43.44 169.66,43.44 v1(169.24,43.02) ; VU5.1 v1(186.96,30.7)
PANEL_BIST_ON_R: length 6
  TOP w0.102: R285.1 152.04,11.56 151.96,11.49 VR2.1 151.21,11.2 v1(151.21,10.76) 150.47,10.02 v2(149.43,10.02)
  BOTTOM w0.102: P2.6 150.25,10.06 150.45,10.25 150.7,10.25 v1(151.21,10.76)
PASSWORD_CLR: length 78.1
  TOP w0.102: v1(89.33,73.91) 88.75,73.91 v2(88.62,74.03)
  IN2 w0.089: 45.65,70.93 45.65,69.26 43.06,66.68 39.79,66.68 39.3,66.19 v1(38.62,66.19)
  IN2 w0.102: 45.65,70.93 47.74,73.03 52.81,73.03 53.27,73.49 57.33,73.49 57.75,73.07 64.12,73.07 64.55,73.51 67.41,73.51 68.6,74.69 76.1,74.69 76.89,73.91 v1(89.33,73.91)
  BOTTOM w0.089: v1(38.62,66.19) 38.28,65.85 U1.AM4
  BOTTOM w0.102: R78.1 83.85,88.36 83.72,88.23 SR9.2 84.99,86.57 84.99,84.73 84.56,84.29 84.56,83.14 82.77,81.35 82.77,78.15 84.34,76.58 87.14,76.58 88.28,75.45 88.28,74.48 88.85,73.91 v1(89.33,73.91)
PASSWORD_CLR_R: length 7.8
  BOTTOM w0.102: E2.2 87.07,84.14 86.78,83.85 86.17,83.85 85.8,84.21 85.8,87.57 84.7,88.67 R78.2
PCB_ID0_EC: length 4.1
  BOTTOM w0.102: R455.2 102.39,71.33 102.49,71.43 R191.2 103.27,71.86 103.27,72.22 103.68,72.64 103.68,72.89 104.18,73.39 U10.119
PCB_ID1_EC: length 5.5
  BOTTOM w0.102: R456.2 R190.2 101.55,70.91 101.55,71.62 101.7,71.77 102.19,71.77 102.47,72.05 102.47,72.17 v2(102.68,72.38) 102.58,72.48 U10.123
PCB_ID2_EC: length 12.1
  TOP w0.102: T25.1 111.13,80.18 v1(111.08,80.23)
  BOTTOM w0.102: v1(111.08,80.23) 111.97,79.33 U10.87 115.55,79.33 116.2,78.68 116.41,78.68 116.89,78.2 116.89,77.4 R457.2 117.14,76.73 117.03,76.62 117.03,75.37 116.7,75.04 R203.2
PCH_DPWROK: length 69.4
  TOP w0.102: v1(89.72,82.72) 90.18,83.18 92.53,83.18 R192.2 ; v1(52.35,77.06) 52.35,77.72 v2(52.75,78.12) 52.86,78.22 52.86,80.26 54.68,82.08 56.34,82.08 58.89,84.64 59.74,84.64 60.01,84.9 65.95,84.9 67.3,86.25 71.9,86.25 72.34,86.69 78.1,86.69 79.21,85.58 v1(79.21,85.07)
  IN1 w0.127: v1(89.72,82.72) 89.32,82.31 87.64,82.31 87.36,82.03 81.51,82.03 80.5,83.04 80.2,83.04 79.21,84.03 v1(79.21,85.07)
  BOTTOM w0.089: 47.75,69.31 47.32,68.88 47.32,67.58 46.99,67.25 46.99,66.31 46.41,65.73 46.03,65.73 45.54,65.24 43.84,65.24 43.49,64.89 42.37,64.89 42.13,65.14 U1.AV5
  BOTTOM w0.102: v1(52.35,77.06) 51.93,76.64 PR13.1 50.4,76 50.4,74.27 49.07,72.95 49.07,70.63 47.75,69.31
PCH_GPIO26_R: length 4.5
  BOTTOM w0.102: SR2.2 54.91,66.11 Q1.1 53.94,65.46 54.46,64.94 v2(55.73,64.94)
PCH_GPIO26_R_C: length 2.6
  BOTTOM w0.102: v2(54.64,62.15) 54.64,62.65 54.61,62.69 SR1.2 54.14,63.14 53.94,63.34 Q1.2
PCH_INTVRMEN: length 24.4
  TOP w0.102: v2(53.29,75.02) 52.48,75.02 52,74.54 52,73.27 52.05,73.22 R75.2 51.45,72.83 51.23,72.61 v1(51.23,72.12)
  TOP w0.178: R72.1 53.86,69.18 v1(53.34,69.18)
  BOTTOM w0.178: U1.AV7 41.9,63.64 42.21,63.34 43.59,63.34 43.62,63.36 44.88,63.36 45.37,63.85 46.64,63.85 47.78,64.99 47.78,66.5 49.08,67.8 50.82,67.8 52.21,69.18 v1(53.34,69.18) 53.34,69.69 51.92,71.11 51.92,71.42 v1(51.23,72.12)
PCH_JTAG_TCK: length 45.8
  TOP w0.102: GR18.2 GR17.2 61.61,8.82 v1(61.37,9.06)
  IN2 w0.102: v1(35.9,18) 36.45,18.55 39.93,18.55 40.86,17.61 42.41,17.61 46.64,13.39 56.06,13.39 58.42,11.03 59.3,11.03 60.46,9.87 60.56,9.87 v1(61.37,9.06)
  BOTTOM w0.089: U1.AE62 34.74,29.53 34.74,28.89 34.61,28.76 34.61,27.77 33.91,27.07 33.91,26.68 34.34,26.25 34.34,25.37
  BOTTOM w0.102: 34.34,25.37 34.65,25.06 35.5,25.06 GR37.1 36.53,24.03 36.53,22.04 v2(36.02,21.53) 35.9,21.42 v1(35.9,18)
PCH_JTAG_TDI: length 82.7
  TOP w0.102: v1(81.61,8.35) 81.1,8.35 80.78,8.68 XDP1.56 80.78,11.35 81.26,11.83 81.79,11.83 82.03,12.07 83.38,12.07 GR20.2
  IN2 w0.102: v1(51.64,5.43) 53.1,6.89 64.51,6.89 66.82,4.58 75.64,4.58 79.41,8.35 v1(81.61,8.35)
  BOTTOM w0.089: U1.AD61 33.97,30.15 33.97,28.72 34.02,28.68 34.02,27.94 33.38,27.3 33.38,26.46 33.55,26.28 33.55,25.63 33.29,25.37
  BOTTOM w0.102: v1(51.64,5.43) 51.22,5.01 50.6,5.01 50.17,5.44 45.33,5.44 44.92,5.85 44.92,10.58 40.25,15.26 34.19,15.26 v2(33.76,15.69) 32.18,17.26 32.18,18.81 GR28.2 32.67,19.85 32.46,20.06 GR38.1 31.98,21.21 31.98,24.06 GR32.2 33.29,25.37
PCH_JTAG_TDO: length 80.6
  TOP w0.102: GR21.1 83.81,16.43 GR16.1 84.34,15.9 84.34,15.16 84.35,15.15 v1(83.52,14.32)
  IN2 w0.102: v1(83.52,14.32) 75.33,6.13 75.33,5.8 74.32,4.78 66.9,4.78 64.59,7.09 52.67,7.09 v1(51,5.43)
  BOTTOM w0.089: U1.AE61 34.15,30.15 34.15,28.86 34.2,28.81 34.2,27.86 33.55,27.22 33.55,26.53 33.73,26.35 33.73,25.37
  BOTTOM w0.102: v1(51,5.43) 50.79,5.64 45.41,5.64 45.12,5.93 45.12,10.66 40.25,15.54 36.3,15.54 v2(35.41,16.43) 34.22,17.62 34.22,18.81 GR29.2 GR35.1 33.25,21.21 33.25,24.06 GR33.2 33.73,25.37
PCH_JTAG_TMS: length 101.3
  TOP w0.102: v1(89.61,7.89) 89.61,8.5 88.75,9.36 87.05,9.36 85.62,10.79 83.72,10.79 83.47,10.53 83.47,9.26 82.97,8.77 81.49,8.77 81.28,8.98 XDP1.58
  IN2 w0.102: v1(52.27,5.43) 53.42,6.57 55.17,6.57 55.72,6.02 63.4,6.02 65.05,4.37 75.72,4.37 79.22,7.87 84.28,7.87 84.89,8.48 86.08,8.48 86.51,8.91 89,8.91 89.61,8.3 v1(89.61,7.89)
  BOTTOM w0.089: 32.79,25.37 33.33,25.91 33.33,26.26 33.2,26.39 33.2,27.37 33.22,27.39 33.22,28.61 33.4,28.8 33.4,29.54 U1.AD62
  BOTTOM w0.102: 32.79,25.37 32.44,25.02 31.68,25.02 GR34.2 30.52,23.87 30.52,22.34 30.84,22.03 30.84,21.24 GR36.1 GR30.2 31.95,18.69 v2(31.95,16.3) 31.95,15.44 32.45,14.94 40.28,14.94 44.72,10.5 44.72,5.76 45.24,5.24 49.82,5.24 50.26,4.81 51.65,4.81 v1(52.27,5.43) ; GU1.9 90.32,7.18 v1(89.61,7.89)
PCH_JTAGX: length 85.9
  TOP w0.102: GR23.2 83.26,16.91 85.53,16.91 86.84,15.61 87.69,15.61 88.39,14.91 88.39,13.1 v1(87.71,12.41) ; v1(62.16,11.19) 62.16,11.17 61.6,10.61 61.29,10.61 59.56,8.88 58.97,8.88 GR19.2
  IN2 w0.102: v1(34.63,17.95) 35.43,18.75 40.01,18.75 40.94,17.82 42.5,17.82 46.72,13.59 56.34,13.59 58.45,11.48 59.14,11.48 59.82,10.8 61.76,10.8 v1(62.16,11.19)
  BOTTOM w0.089: U1.AE63 34.44,28.88 34.42,28.86 34.42,27.84 33.73,27.15 33.73,26.61 34.05,26.29 34.05,25.37
  BOTTOM w0.102: v1(87.71,12.41) 87.2,11.9 75.01,11.9 73.84,13.07 72.09,13.07 71.39,13.77 67.24,13.77 65.29,11.82 65.29,11.82 65.12,11.82 65.12,11.82 62.83,11.82 62.21,11.19 v1(62.16,11.19) ; 34.05,25.37 GR31.2 34.37,24.03 34.37,22.06 34.8,21.63 34.8,20.59 35,20.39 v2(35,19.85) 34.63,19.49 v1(34.63,17.95)
PCH_OPIRCOMP: length 10.7
  BOTTOM w0.178: U1.AW15 42.9,59.59 43.39,59.59 43.8,60 45.77,60 46.43,59.34 48.37,59.34 48.64,59.07 v2(48.64,56.94) 48.64,56.68 48.94,56.38 SR19.1
PCIE_RCOMP: length 4.8
  TOP w0.089: SR10.2 18.31,52.24 v1(18.65,51.91) 18.9,52.16 19.94,52.16 v2(20.17,52.39)
  BOTTOM w0.089: U1.A27 20.3,51.96 19.8,51.46 19.09,51.46 v1(18.65,51.91)
PCIE_RXN3_WLAN: length 217.5
  IN3 w0.114: v1(23.99,61.87) 23.51,62.35 22.64,62.35 22.39,62.6 22.39,64.34 21.77,64.97 21.77,66.34 23.78,68.34 25.33,68.34 25.74,68.76 25.74,69.58 25.88,69.72 25.88,73.8 26.32,74.23 26.32,76.83 28.55,79.06 32.98,79.06 33.49,79.57 35.23,79.57 35.81,80.15 36.98,80.15 37.37,80.54 40.46,80.54 40.89,80.97 45.75,80.97 46.36,80.36 48.79,80.36 49.98,81.54 54.5,81.54 55.12,82.15 55.9,82.15 56.8,83.06 58.08,83.06 59.3,84.28 60.56,84.28 61.6,85.32 66.71,85.32 67.43,86.04 83.82,86.04 84.18,86.4 88.58,86.4 90.48,84.5 96.45,84.5 96.86,84.09 99.46,84.09 100.55,85.18 113.31,85.18 114.38,84.12 118.01,84.12 118.75,84.85 131.49,84.85 133.24,86.61 140.03,86.61 141.96,84.68 149.27,84.68 150.34,85.74 163.68,85.74 166.27,83.15 166.56,83.15 v4(166.75,82.96) 166.95,83.15 167.41,83.15 168.35,82.21 169.82,82.21 171.15,80.88 171.15,76.77 175.87,72.04 175.87,62.58 177.06,61.39 177.06,58.75 178.08,57.73 178.08,55.83 178.89,55.02 179.73,55.02 180.11,54.63 180.11,52.6 181.19,51.53 182.02,51.53 182.7,50.84 183.39,50.84 184.05,51.5 184.05,52.06 183.54,52.57 v1(182.87,52.57)
  BOTTOM w0.102: U1.G11 24.26,61.57 24.26,61.6 v1(23.99,61.87) ; CONWIFI.43 181.42,52.35 181.94,51.83 182.13,51.83 v1(182.87,52.57)
PCIE_RXN4_WLAN: length 208.2
  IN3 w0.089: v1(23.42,60.93) 23.42,61.21 23.34,61.28 22.63,61.28 21.54,62.38 21.54,64.03 20.48,65.08 20.48,66.12 24.34,69.97 24.34,70.87 24.33,70.88 24.33,70.91 24.29,70.95 24.29,70.96
  IN3 w0.114: v1(178.79,58.72) 178.48,58.72 178.08,59.12 178.08,61.92 177.37,62.63 177.37,72.15 172.11,77.41 172.11,81.37 168.48,85.01 167.13,85.01 165.32,86.81 155.32,86.81 v4(155.12,87.01) 154.92,86.81 154.6,86.81 154.12,87.29 151.74,87.29 151.26,86.81 149.64,86.81 148.93,86.1 142.19,86.1 140.72,87.57 132.82,87.57 131.17,85.92 118.79,85.92 118.54,86.17 99.88,86.17 99.37,85.67 96.93,85.67 96.73,85.46 94.46,85.46 92.14,87.79 78.96,87.79 78.18,87.01 66.94,87.01 66.58,86.66 65.18,86.66 64.95,86.42 60.14,86.42 59.73,86.02 59.73,85.46 59.51,85.23 58.91,85.23 57.69,84.01 56.39,84.01 55.49,83.11 54.72,83.11 54.13,82.52 49.49,82.52 48.89,81.92 41.55,81.92 40.96,82.51 39.62,82.51 38.6,81.49 37.42,81.49 36.42,82.49 34.49,82.49 32.58,80.57 29.43,80.57 28.98,80.13 26.98,80.13 25.35,78.5 25.35,76.9 24.93,76.47 24.44,76.47 24,76.04 24,73.68 24.29,73.4 24.29,70.96
  BOTTOM w0.102: v1(23.42,60.93) 23.78,60.56 U1.F13 ; CONWIFI.67 179.65,58.35 179.55,58.26 179.25,58.26 v1(178.79,58.72)
PCIE_RXN6_CR: length 40.4
  TOP w0.102: v1(5.23,84.28) 5.01,84.5 4.35,84.5 3.91,84.06 3.91,76.37 ; v1(23.5,62.81) 23.14,63.17 22.12,63.17 21.72,63.57 21.72,66.31 20.51,67.52 20.19,67.52 19.87,67.84 18.28,67.84 18.04,68.09 18.04,68.82 17.43,69.42 16.68,69.42 15.4,70.71 14.81,70.71 14.34,71.18 11.47,71.18 11.23,71.42 6.23,71.42 3.91,73.74 3.91,76.37 ; 3.91,76.37 v2(4.2,76.37)
  BOTTOM w0.102: v1(23.5,62.81) 23.5,62.71 23.78,62.43 U1.F10 ; CON10.41 5.2,84.24 v1(5.23,84.28)
PCIE_RXP3_WLAN: length 217.5
  IN3 w0.114: v1(23.33,61.86) 23.33,62.09 23.29,62.12 22.54,62.12 22.16,62.5 22.16,64.25 21.54,64.87 21.54,66.43 23.68,68.57 25.23,68.57 25.51,68.85 25.51,69.67 25.65,69.82 25.65,73.89 26.09,74.32 26.09,76.92 28.46,79.29 32.89,79.29 33.4,79.8 35.14,79.8 35.71,80.38 36.89,80.38 37.28,80.76 40.36,80.76 40.79,81.2 45.84,81.2 46.45,80.59 48.7,80.59 49.88,81.77 54.41,81.77 55.02,82.38 55.81,82.38 56.71,83.28 57.99,83.28 59.21,84.5 60.47,84.5 61.51,85.55 66.61,85.55 67.34,86.27 83.73,86.27 84.09,86.63 88.67,86.63 90.58,84.73 96.55,84.73 96.95,84.32 99.37,84.32 100.46,85.41 113.41,85.41 114.47,84.35 117.92,84.35 118.65,85.08 131.4,85.08 133.15,86.83 140.13,86.83 142.06,84.9 149.18,84.9 150.24,85.97 163.77,85.97 166.36,83.38 167.51,83.38 168.45,82.44 168.69,82.44 v4(168.89,82.64) 169.08,82.44 169.91,82.44 171.38,80.98 171.38,76.86 176.1,72.14 176.1,62.68 177.29,61.49 177.29,58.84 178.31,57.83 178.31,55.92 178.98,55.25 179.82,55.25 180.34,54.73 180.34,52.7 181.28,51.76 182.11,51.76 182.8,51.07 183.3,51.07 183.82,51.6 183.82,51.97 183.51,52.28 183.33,52.28 183.26,52.21 183.26,51.76 183.13,51.63 182.96,51.63 182.83,51.76 v1(182.83,51.93)
  BOTTOM w0.102: U1.F11 23.54,61.39 23.44,61.49 23.44,61.75 v1(23.33,61.86) ; CONWIFI.41 181.63,51.85 181.86,51.63 182.21,51.63 182.52,51.94 182.83,51.94 v1(182.83,51.93)
PCIE_RXP4_WLAN: length 208.1
  IN3 w0.089: 24.52,70.96 24.52,69.9 20.66,66.04 20.66,65.16 21.72,64.1 21.72,62.45 22.71,61.46 23.45,61.46 23.98,60.93 v1(24.04,60.93)
  IN3 w0.114: 24.52,70.96 24.52,73.5 24.23,73.78 24.23,75.94 24.53,76.24 25.02,76.24 25.58,76.8 25.58,78.4 27.08,79.9 29.08,79.9 29.52,80.34 32.67,80.34 34.59,82.26 36.32,82.26 37.33,81.26 38.69,81.26 39.71,82.28 40.87,82.28 41.46,81.69 48.99,81.69 49.58,82.29 54.23,82.29 54.82,82.88 55.58,82.88 56.48,83.78 57.78,83.78 59.01,85.01 59.6,85.01 59.96,85.36 59.96,85.92 60.23,86.19 65.04,86.19 65.28,86.43 66.68,86.43 67.03,86.78 78.28,86.78 79.05,87.56 92.05,87.56 94.37,85.23 96.83,85.23 97.03,85.44 99.47,85.44 99.98,85.95 118.44,85.95 118.7,85.69 131.27,85.69 132.92,87.34 140.62,87.34 142.1,85.87 149.02,85.87 149.73,86.58 151.35,86.58 151.84,87.06 153.06,87.06 v4(153.29,86.83) 153.52,87.06 154.03,87.06 154.51,86.58 165.23,86.58 167.03,84.78 168.38,84.78 171.88,81.28 171.88,77.32 177.14,72.06 177.14,62.53 177.85,61.82 177.85,59.03 v1(178.82,58.06)
  BOTTOM w0.102: v1(24.04,60.93) 24.43,60.54 U1.G13 ; CONWIFI.65 179.79,57.85 179.59,58.06 v1(178.82,58.06)
PCIE_RXP6_CR: length 40.3
  TOP w0.102: v1(5.22,84.91) 5.01,84.7 4.27,84.7 3.71,84.14 3.71,83.97 3.71,74.77 ; 3.71,74.77 3.71,73.65 6.15,71.21 11.14,71.21 11.39,70.97 14.26,70.97 14.73,70.5 15.32,70.5 16.6,69.22 17.35,69.22 17.85,68.72 17.85,68.01 18.21,67.65 19.79,67.65 20.12,67.33 20.43,67.33 21.53,66.23 21.53,63.48 22.03,62.97 22.64,62.97 v1(22.84,62.77) ; 3.71,74.77 v2(3.42,74.77)
  BOTTOM w0.102: v1(22.84,62.77) 23.13,62.48 U1.E10 ; v1(5.22,84.91) 5.05,84.74 CON10.40
PCIE_TXN3_WLAN: length 227.3
  TOP w0.102: v1(181.91,53.97) 181.68,54.2 181.59,54.2 SC9.2
  IN3 w0.114: v1(20.83,50.18) 20.55,50.18 20.46,50.27 20.46,50.6 21.58,51.73 21.58,61.89 20.82,62.65 20.82,64.19 20.17,64.84 20.17,66.51 21.87,68.22 21.87,72.57 23.14,73.84 23.14,77.06 24.03,77.94 24.03,79.96 26.33,82.26 31.57,82.26 32.03,82.72 33.37,82.72 33.66,83.01 41.32,83.01 41.81,82.52 48.77,82.52 49.3,83.05 53.97,83.05 54.52,83.6 55.24,83.6 56.14,84.5 57.48,84.5 59.89,86.92 63.73,86.92 64.63,87.82 68.44,87.82 68.74,87.52 77.99,87.52 78.75,88.28 93.29,88.28 94.56,87.01 99.34,87.01 99.93,87.6 101.02,87.6 102.27,88.85 132.87,88.85 133.49,88.23 141.11,88.23 142.71,86.63 148.16,86.63 149.4,87.88 166.96,87.88 168.54,86.3 171.76,86.3 173.56,84.5 173.56,82.71 v4(173.36,82.52) 173.56,82.32 173.56,78.45 177.14,74.87 177.14,73.14 178.82,71.47 178.82,67.21 180.95,65.07 180.95,54.68 181.24,54.39 181.49,54.39 v1(181.91,53.97)
  BOTTOM w0.102: v1(20.83,50.18) 21.2,50.18 21.35,50.33 21.62,50.33 21.74,50.21 21.88,50.21 21.97,50.3 21.97,50.43 U1.C29
PCIE_TXN3_WLAN_S: length 7.1
  TOP w0.102: SC9.1 180.42,54.2 180.34,54.27 180.04,54.27 179.96,54.19 179.96,53.89 179.25,53.18 179.25,53.08 v1(179.5,52.82)
  BOTTOM w0.102: CONWIFI.37 179.79,50.85 179.6,50.66 179.15,50.66 178.67,51.15 178.67,52.19 178.89,52.41 178.89,52.51 179.2,52.82 v1(179.5,52.82)
PCIE_TXN4_WLAN: length 226.2
  TOP w0.102: v1(182.5,61.56) 182.25,61.31 180.52,61.31 180.06,60.85 180.06,60.44 179.94,60.32 179.53,60.32 179.4,60.19 SC11.2
  IN3 w0.114: v1(19.81,51.03) 19.81,51.48 20.88,52.56 20.88,61.55 20.23,62.2 20.23,63.63 19.59,64.27 19.59,68.4 20.63,69.44 20.63,72.89 21.59,73.86 21.59,74.95 21.39,75.15 21.39,76.57 23.17,78.35 23.17,80.14 26.02,82.99 31.21,82.99 31.68,83.46 32.81,83.46 33.08,83.73 46.83,83.73 47.49,84.4 54.99,84.4 55.82,85.23 57.18,85.23 59.59,87.64 63.39,87.64 64.29,88.54 68.3,88.54 68.97,89.21 71.53,89.21 72.49,88.24 77.43,88.24 78.2,89.01 93.59,89.01 94.86,87.74 98.82,87.74 100.71,89.63 141.89,89.63 142.91,88.61 167.32,88.61 168.79,87.14 173.69,87.14 176,84.83 176,82.64 v4(175.8,82.44) 176,82.24 176,81.65 175.64,81.3 175.64,79.4 178.97,76.07 178.97,72.59 180.19,71.37 180.19,68.38 180.77,67.79 180.77,66.57 183.21,64.13 183.21,61.48 183.12,61.38 182.68,61.38 v1(182.5,61.56)
  BOTTOM w0.089: U1.B29 21.28,50.58 21.39,50.69 21.39,50.84 21.31,50.92 19.92,50.92 v1(19.81,51.03)
PCIE_TXN4_WLAN_S: length 5.4
  TOP w0.102: 179.83,58.03 179.83,57.59 180.19,57.24 180.19,56.63 180.07,56.51 179.9,56.51 179.78,56.63 179.78,56.86 179.7,56.94 179.49,56.94 v1(179.47,56.95) ; 179.83,58.03 v2(179.54,58.03) ; 179.83,58.03 179.83,58.4 179.73,58.51 179.73,58.75 SC11.1
  BOTTOM w0.102: CONWIFI.61 179.56,56.85 179.47,56.94 v1(179.47,56.95)
PCIE_TXN6_CR: length 48.5
  IN1 w0.127: v1(17.27,55.19) 17.48,55.39 17.48,55.85 17.01,56.32 16.09,56.32 15.47,56.94 15.47,60.39 15.04,60.82 15.04,62.13 14,63.17 14,67.55 11.71,69.84 6.76,69.84 2.64,73.96 2.64,79.59 3.07,80.02 3.07,85.52 2.8,85.8 2.55,85.8 2.25,85.5 v1(2.07,85.5)
  BOTTOM w0.089: U1.C23 21.67,54.68 20.91,54.68 20.61,54.98 19.69,54.98 19.65,54.95
  BOTTOM w0.102: 18.39,54.6 19.31,54.6 19.65,54.95 ; 18.39,54.6 17.86,54.6 v1(17.27,55.19) ; 18.39,54.6 v2(18.39,54.31) ; CON10.38 2.52,85.74 2.28,85.5 v1(2.07,85.5)
PCIE_TXP3_WLAN: length 227.3
  TOP w0.102: SC8.2 181.57,54.4 181.67,54.4 v1(181.89,54.62)
  IN3 w0.114: v1(20.04,50.18) 20.23,50.37 20.23,50.7 21.35,51.82 21.35,61.79 20.59,62.55 20.59,64.09 19.94,64.74 19.94,66.61 21.64,68.31 21.64,72.67 22.91,73.94 22.91,77.15 23.8,78.04 23.8,80.05 26.24,82.49 31.48,82.49 31.94,82.95 33.28,82.95 33.56,83.23 41.42,83.23 41.9,82.75 48.67,82.75 49.21,83.28 53.87,83.28 54.42,83.83 55.15,83.83 56.05,84.73 57.39,84.73 59.8,87.15 63.63,87.15 64.54,88.05 68.54,88.05 68.84,87.75 77.9,87.75 78.66,88.51 93.39,88.51 94.66,87.24 99.25,87.24 99.83,87.83 100.92,87.83 102.18,89.08 132.96,89.08 133.59,88.46 141.2,88.46 142.8,86.86 148.06,86.86 149.31,88.1 167.06,88.1 168.63,86.53 171.86,86.53 173.79,84.6 173.79,80.4 v4(173.99,80.21) 173.79,80.01 173.79,78.55 177.37,74.97 177.37,73.24 179.05,71.56 179.05,67.3 181.18,65.17 181.18,54.77 181.34,54.62 v1(181.89,54.62)
  BOTTOM w0.102: v1(20.04,50.18) 20.22,50.18 20.65,49.75 21.06,49.75 21.33,50.02 U1.B30
PCIE_TXP3_WLAN_S: length 7.1
  TOP w0.102: v1(178.69,52.93) 178.69,52.94 178.7,52.95 178.73,52.95 179.76,53.97 179.76,54.27 179.96,54.47 180.2,54.47 SC8.1
  BOTTOM w0.102: CONWIFI.35 179.79,50.35 179.68,50.46 179.06,50.46 178.46,51.06 178.46,52.27 178.69,52.49 v1(178.69,52.93)
PCIE_TXP4_WLAN: length 226.2
  TOP w0.102: v1(182.5,60.93) 182.32,61.1 180.6,61.1 180.27,60.77 SC10.2
  IN3 w0.114: v1(182.5,60.93) 182.73,61.16 183.21,61.16 183.44,61.38 183.44,64.23 181,66.67 181,67.89 180.42,68.47 180.42,71.47 179.2,72.69 179.2,76.17 175.87,79.49 175.87,79.98 v4(176.07,80.18) 175.87,80.38 175.87,81.2 176.23,81.56 176.23,84.93 173.79,87.37 168.89,87.37 167.41,88.84 143,88.84 141.99,89.86 100.62,89.86 98.73,87.96 94.96,87.96 93.69,89.23 78.1,89.23 77.34,88.47 72.58,88.47 71.62,89.43 68.87,89.43 68.21,88.77 64.19,88.77 63.29,87.87 59.5,87.87 57.08,85.46 55.73,85.46 54.9,84.62 47.4,84.62 46.73,83.96 32.99,83.96 32.72,83.68 31.58,83.68 31.11,83.21 25.92,83.21 22.94,80.23 22.94,78.45 21.16,76.67 21.16,75.06 21.36,74.85 21.36,73.95 20.4,72.98 20.4,69.53 19.36,68.5 19.36,64.18 20,63.54 20,62.11 20.65,61.46 20.65,52.65 19.58,51.58 19.58,51.54 19.39,51.36 19.39,50.53 v1(19.46,50.46)
  BOTTOM w0.089: U1.A29 20.48,50.61 19.61,50.61 v1(19.46,50.46)
PCIE_TXP4_WLAN_S: length 5.4
  TOP w0.102: v2(180.68,56.71) 180.39,56.71 ; 180.39,56.71 180.39,56.55 180.15,56.31 v1(179.5,56.31) ; 180.39,56.71 180.39,57.32 180.04,57.68 180.04,58.49 179.94,58.59 179.94,58.75 SC10.1
  BOTTOM w0.102: v1(179.5,56.31) 179.5,56.3 179.55,56.35 CONWIFI.59
PCIE_TXP6_CR: length 48.2
  IN1 w0.127: v1(2.26,86.13) 2.36,86.03 2.89,86.03 3.3,85.62 3.3,79.93 2.87,79.49 2.87,74.05 6.85,70.07 11.81,70.07 14.23,67.65 14.23,63.26 15.27,62.23 15.27,60.92 15.7,60.49 15.7,57.03 16.18,56.55 17.11,56.55 17.71,55.95 17.71,55.39 v1(17.91,55.19)
  BOTTOM w0.089: U1.C22 22.21,55.04 21.55,55.04 21.37,54.86 20.99,54.86 20.68,55.16 19.59,55.16 19.58,55.15 19.57,55.15 19.53,55.11 19.52,55.11 19.51,55.09
  BOTTOM w0.102: v1(2.26,86.13) 2.37,86.24 CON10.37 ; v1(17.91,55.19) 17.91,54.93 18.04,54.81 19.22,54.81 19.51,55.09
PCIE_WAKE#: length 279.3
  TOP w0.102: v1(106.22,22.12) 103.81,22.12 102.63,20.93 R279.2 ; v1(113.31,69.99) 113.31,69.64 113.72,69.23 113.72,68.81 112.98,68.08 110.58,68.08 110.36,68.29 109.31,68.29 109.11,68.09 108.13,68.09 v1(107.9,67.86) ; v1(83.9,80.94) 81.92,82.92 81.92,84.09 82.48,84.65 83.07,84.65 83.33,84.91 83.33,85.29 82.8,85.81 82.8,87.34 82.43,87.71 71.92,87.71 71.48,87.27 66.88,87.27 66.12,86.5 64.8,86.5 64.51,86.8 58.71,86.8 55.7,83.79 52.54,83.79 51.83,83.08 49.58,83.08 49.23,82.73 49.23,78.68 49.77,78.14 49.77,77.11 49.42,76.75 48.71,76.75 48.38,76.42 47.69,76.42 PR12.2 46.5,75.23 46.5,74.89 45.48,73.87 42,73.87 v1(41.49,73.37) ; R60476.1 178.28,59.99 179.57,61.27 179.57,62.75 179.28,63.03 v1(178.13,63.03) ; v1(114.81,33.72) 114.99,33.55 v2(114.99,22.75) v1(114.99,21.66)
  IN1 w0.102: v1(106.22,22.12) 110.41,22.12 110.43,22.1 114.54,22.1 v1(114.99,21.66) 115.41,21.24 117.58,21.24 118.33,21.99 120.8,21.99 121.38,21.42 128.16,21.42 129.16,22.42 136.55,22.42 143.94,29.81 149.43,29.81 153.16,33.55 155.77,33.55 158.62,36.39 160.97,36.39 164.58,40 165.55,40 167.32,41.77 167.32,45.49 169.65,47.81 169.65,53.43 170.32,54.11 170.32,57.62 175.15,62.45 177.55,62.45 v1(178.13,63.03) ; v1(114.81,33.72) 111.61,36.92 108.23,36.92 107.43,37.72 107.43,40.52 108.47,41.55 108.47,58.54 108.67,58.74 108.67,59.9 108.09,60.48 108.09,64.5 107.54,65.05 107.54,66.64 107.9,67 v1(107.9,67.86) 106.82,67.86 105.32,69.36 103.55,69.36 103.02,69.89 103.02,70.07 99.72,73.37 99.72,74.79 98.24,76.27 97.12,76.27 95.25,78.14 95.25,78.69 94.12,79.81 92.11,79.81 91.9,79.6 88.89,79.6 88.73,79.43 87.57,79.43 86.56,78.43 86.17,78.43 85.7,78.9 85.7,79.14 v1(83.9,80.94)
  IN2 w0.089: v1(35.9,65.35) 35.84,65.35 34.85,66.34 34.85,67.11 34.65,67.31 34.65,70.93
  IN2 w0.102: 34.65,70.93 34.65,71 36.23,72.58 36.23,73.3 36.98,74.05 40.27,74.05 40.95,73.37 v1(41.49,73.37)
  BOTTOM w0.089: v1(35.9,65.35) 36.08,65.17 U1.AJ5
  BOTTOM w0.102: v1(113.31,69.99) 113.31,70.13 112.84,70.6 R205.2
PCIE_WAKE#_EC: length 4.1
  BOTTOM w0.102: v2(113.32,72.41) 113.32,71.93 R205.1 112.83,71.82 112.18,72.47 U10.99
PECI_EC_LPCSB: length 6.9
  TOP w0.089: v1(28.64,26.7) 29.31,26.02 29.31,24.79 R114.2
  BOTTOM w0.089: U1.N62 28.02,29.5 28.02,27.5 v2(27.66,27.14) 28.11,26.7 v1(28.64,26.7)
PLT_RST#: length 427.1
  TOP w0.102: Q3.2 106.93,74.51 107.13,74.71 107.13,74.73 ; v1(63.45,88.72) 61.91,88.72 61.53,88.35 56.76,88.35 56.44,88.03 52.6,88.03 49.84,85.27 48.01,85.27 45.72,82.98 45.72,82.75 43.32,80.36 42.77,80.36 42.15,79.74 41.43,79.74 39.27,77.58 39.27,77.07 38.28,76.08 v1(37.68,76.08) ; Q3.5 107.35,74.51 107.13,74.73 ; R171.2 123.06,30.75 v1(122.89,30.57) 122.89,28.67 v2(122.53,28.31) 121.71,27.49 GR14.1 ; v1(4.75,73.65) 4.75,77 4.56,77.2 4.56,83.5 4.85,83.79 5.43,83.79 5.71,84.08 5.71,85.1 5.68,85.14 5.68,85.94 6.13,86.39 6.99,86.39 7.33,86.05 7.33,84.72 7.84,84.21 8.46,84.21 R60475.2 ; v1(107.13,75.22) 107.13,74.73 ; v1(161.93,61.66) 162.54,61.66 162.84,61.36 164.96,61.36 168.35,57.97 172.05,57.97 173.14,56.88 R60472.2
  IN1 w0.089: 34.6,70.53 34.6,68.75 33.45,67.61 33.45,62.96 32.97,62.48 32.97,60.33 33.22,60.09 33.76,59.55 34.33,59.55 35.18,60.4 35.18,62.88 35.38,63.09 35.38,63.55 v1(35.9,64.06)
  IN1 w0.127: v1(152.63,67.94) 152.08,67.39 148.87,67.39 148.62,67.64 148.62,70.53 144.3,74.85 141.2,74.85 140.71,74.36 131.99,74.36 129.49,76.85 129.49,80.04 128.61,80.92 107.91,80.92 106.06,82.77 103.05,82.77 v1(102.62,82.34) ; 34.6,70.53 34.6,71.7 35.56,72.66 35.56,74.13 34.95,74.74 34.95,75.79 35.24,76.08 v1(37.68,76.08) 38.72,76.08 39.3,76.65 39.3,78.25 39.07,78.48 37.7,78.48 36.55,79.62 33.55,79.62 33.4,79.47 27,79.47 26.41,78.88 23.66,78.88 22.24,77.46 21.27,77.46 18.85,75.04 17.95,75.04 16.92,74.01 13.95,74.01 13.55,74.4 12.13,74.4 11.61,73.88 11.61,73.19 10.85,72.43 10.06,72.43 9.48,73.02 5.39,73.02 v1(4.75,73.65)
  IN3 w0.102: v1(102.62,82.34) 102.2,82.75 100.67,82.75 100.17,82.26 99.18,82.26 97.85,80.93 94.86,80.93 94.25,81.54 86.12,81.54 85.86,81.79 83.28,81.79 82.78,81.28 76.25,81.28 75.53,80.56 68.09,80.56 67.3,81.35 65.42,81.35 63.97,82.8 63.21,82.8 62.17,81.75 60.38,81.75 59.16,80.54 58.13,80.54 55.98,78.39 53.4,78.39 52.89,77.88 51.37,77.88 50.65,77.16 48.59,77.16 48.44,77.32 47.86,77.32 46.66,76.11 41.38,76.11 41.17,76.32 39.63,76.32 39.17,75.86 37.9,75.86 v1(37.68,76.08) ; v1(122.89,30.57) 127.31,34.99 134.94,34.99 136.39,36.44 154.26,36.44 155.83,38.02 155.83,47.36 159.64,51.17 159.64,54.42 160.4,55.19 160.4,59.35 161.94,60.89 161.94,61.66 ; v1(107.13,75.22) 106.66,74.74 100.79,74.74 98.58,72.53 96.24,72.53 94.08,70.38 93.85,70.38 v1(93.85,70.38) ; v1(63.45,88.72) 64.05,89.32 66.83,89.32 67.43,89.92 93.72,89.92 v1(95.14,88.5) ; v1(152.63,67.94) 156.95,63.62 159.98,63.62 161.94,61.66 ; v1(161.93,61.66) 161.94,61.66
  BOTTOM w0.089: v1(35.9,64.06) 35.7,63.87 U1.AG7
  BOTTOM w0.102: v1(102.62,82.34) 102.62,83.91 102.4,84.13 U10.22 97.03,84.13 96.69,84.47 96.44,84.47 SC4.1 ; v1(95.14,88.5) 95.14,88.5 95.14,88.51 94.87,88.78 92.65,88.78 91.04,87.16 91.04,86.61 90.65,86.22 90.25,86.22 90.07,86.05 90.07,85.3 92.13,83.24 92.13,80.47 92.79,79.81 92.79,78.55 93.67,77.68 93.67,74.43 93.67,74.43 93.67,74.24 93.07,73.64 93.07,72.05 93.38,71.74 93.38,70.85 93.85,70.38 v1(93.85,70.38)
PLT_RST#_R: length 6
  TOP w0.102: v2(171.91,55.41) 172.51,55.41 R60472.1 R60473.1 174.44,56.04 v1(175.08,55.39)
  BOTTOM w0.102: CONWIFI.52 174.3,54.6 v1(175.08,55.39)
PLTRST_WLAN#: length 217.2
  TOP w0.102: v1(174.74,56.68) 174.55,56.88 R60473.2 ; v2(97.59,87.09) 97.28,86.78 97.28,86.56 v1(97.01,86.29) ; R60474.2 9.45,86.09 v1(10.54,86.09)
  IN1 w0.127: v1(56.29,86.71) 56.29,84.98 58.32,82.95 62.43,82.95 62.93,83.44 64.18,83.44 67.07,80.56 74.07,80.56 75.24,81.73 75.24,85.56 76.1,86.43 83.62,86.43 84.3,87.11 88.95,87.11 90.12,85.95 90.12,85.25 90.67,84.7 92.61,84.7 93.85,85.95 95.04,85.95 95.38,86.29 v1(97.01,86.29) 97.03,86.29 97.51,86.77 99.5,86.77 99.77,86.5 106.3,86.5 106.52,86.28 111.6,86.28 111.6,86.28 111.63,86.28 111.76,86.15 117.43,86.15 117.88,86.61 v1(118.47,86.61)
  IN2 w0.152: v1(118.47,86.61) 118.91,86.16 127.95,86.16 128.91,87.11 132.77,87.11 132.77,87.14 133.2,87.57 142.32,87.57 142.77,87.11 146.66,87.11 149.65,84.13 152.82,84.13 v1(153.77,85.08)
  IN3 w0.102: v1(174.74,56.68) 174.74,57.09 172.87,58.96 172.87,61.61 172.01,62.48 172.01,67.53 172.57,68.09 172.57,72.33 171.05,73.86 171.05,75.96 170.63,76.38 170.63,80.53 170.61,80.54 170.61,80.72 169.84,81.49 168.29,81.49 167.96,81.82 165.86,81.82 165.1,82.58 165.1,83.22 163.62,84.7 158.11,84.7 157.73,85.08 v1(153.77,85.08) ; v1(10.54,86.09) 9.34,86.09 9.15,85.89 9.15,85.16 9.44,84.86 13.86,84.86 14.28,84.45 18,84.45 20.77,87.22 22.79,87.22 24.39,88.83 38.83,88.83 40.02,87.63 51.76,87.63 52.95,88.83 54.72,88.83 56.29,87.26 v1(56.29,86.71)
  BOTTOM w0.102: U10.28 97.85,86.53 97.82,86.57 97.47,86.57 97.19,86.29 v1(97.01,86.29) 96.85,86.45 PR233.2
PM_APWROK_R: length 25.3
  IN1 w0.089: v1(33.04,65.35) 33.04,68.6
  IN1 w0.102: 33.04,68.6 33.04,70.12 33.86,70.93 33.86,72.69 34.32,73.14 34.32,74.69 33.83,75.18 33.83,75.96 34.42,76.55 36.19,76.55 36.8,77.16 v1(38.76,77.16)
  BOTTOM w0.089: U1.AB5 32.86,65.17 v1(33.04,65.35)
  BOTTOM w0.102: v1(38.76,77.16) 39.24,77.64 39.24,78.07 39.14,78.17 39.14,80.61 39.55,81.02 39.55,82.69 v2(39.04,83.2) 38.52,83.72 PR14.2
PM_CLKRUN#: length 196.5
  TOP w0.089: 28.3,71.24 28.3,70.81 30.01,69.1 30.01,65.55 v1(30.19,65.37)
  TOP w0.102: v1(94.87,67.86) 95,67.86 96.3,69.16 97.23,69.16 97.79,69.71 97.79,72.86 98.99,74.06 98.99,74.46 101.32,76.8 101.32,76.8 101.58,77.06 103.76,77.06 103.77,77.07 105.24,77.07 105.77,77.59 105.77,79.6 105.44,79.93 105.44,80.76 105.06,81.14 105.06,82.16 104.88,82.34 v1(104.49,82.34) ; v1(29.79,76.72) 29.64,76.57 29.64,75.42 PR8.2 28.86,74.64 28.65,74.64 28.3,74.29 28.3,71.24 ; R172.2 v1(122.2,30.86) 121.74,30.4 v2(121.74,29.89)
  IN1 w0.127: v1(122.2,30.86) 121.89,30.55 108.46,30.55 107.28,31.73 105.22,31.73 101.12,35.83 101.12,36.47 98.91,38.68 98.49,38.68 93.46,43.7 93.46,48.46 94.45,49.44 94.45,62.94 94.77,63.26 94.77,67.76 v1(94.87,67.86)
  IN3 w0.102: v1(29.79,76.72) 30.74,77.67 33.34,77.67 34.12,76.88 36.07,76.88 36.65,77.46 36.65,78.28 36.58,78.35 36.58,78.68 36.82,78.92 37.23,78.92 37.4,78.74 40.4,78.74 41.4,79.74 42.23,79.74 43.88,78.1 46.53,78.1 47.43,78.99 49.35,78.99 50.6,80.24 54.94,80.24 55.63,80.93 56.47,80.93 57.38,81.83 58.6,81.83 59.82,83.05 61.11,83.05 61.94,83.88 62.46,83.88 62.67,84.09 64.58,84.09 65.75,82.92 74.78,82.92 74.97,82.73 79.47,82.73 79.8,83.06 80.79,83.06 81.26,82.59 82.53,82.59 82.83,82.88 85.99,82.88 86.47,83.37 87.51,83.37 88.17,82.71 89.12,82.71 89.61,83.2 92.25,83.2 93.36,82.1 98.34,82.1 98.98,82.74 99.97,82.74 100.47,83.24 103.59,83.24 v1(104.49,82.34)
  BOTTOM w0.089: U1.V5 30.39,65.17 v1(30.19,65.37)
  BOTTOM w0.102: U10.93 113.74,76.93 113.62,76.81 111.57,76.81 110.76,77.62 110.76,78.09 110.53,78.32 109.49,78.32 108.69,77.51 106.24,77.51 105.39,78.37 105.39,80.56 104.49,81.45 v1(104.49,82.34)
PM_CLKRUN#_R: length 5.2
  TOP w0.102: R172.1 R440.1 121.36,33.16 121.9,33.7 v2(122.2,33.7) 122.68,33.7 123.72,34.74 U9.15
PM_PCH_PWROK_R: length 15.6
  BOTTOM w0.089: 47.75,66.82 47.56,66.62 47.56,65.1 46.61,64.15 45.36,64.15 44.89,63.68 43.14,63.68 U1.AY7
  BOTTOM w0.102: 47.75,66.82 49.1,68.17 50.85,68.17 52.22,69.54 v2(52.22,69.92) 52.22,70.3 PR11.2
PM_PWRBTN#: length 84.7
  TOP w0.102: PR26.1 47.4,73.39 47.4,73.99 48.06,74.66 48.84,74.66 50.6,76.41 50.6,78.18 51.49,79.07 51.49,81.87 52.79,83.18 55.96,83.18 58.97,86.19 61.84,86.19 v2(62.26,85.77) 62.61,85.41 65.89,85.41 67.13,86.66 71.73,86.66 72.18,87.1 78.27,87.1 79.73,85.63 80.15,85.63 80.34,85.44 80.34,84.88 79.27,83.81 v1(79.27,83.15)
  IN1 w0.102: v1(112.6,83.82) 112.06,83.28 111.61,83.28 111.25,82.92 107.41,82.92 106.9,83.43 99.52,83.43 98.62,82.53 92.39,82.53 91.57,81.7 87.68,81.7 87.55,81.58 81.32,81.58 80.31,82.58 79.39,82.58 79.27,82.7 v1(79.27,83.15)
  BOTTOM w0.102: v1(112.6,83.82) 113.02,84.24 113.46,84.24 113.97,83.73 U10.76
PM_PWRBTN#_XDP: length 29.6
  TOP w0.102: XDP1.41 77.28,5.23 73.49,9.02 66.42,9.02 65.27,7.86 65.27,5.76 64.98,5.48 58.74,5.48 GR10.1 57.49,5.4 55.09,5.4 v2(54.59,4.89)
PM_PWROK: length 164.1
  TOP w0.102: R410.2 137.13,73.61 135.87,74.87 133.61,74.87 131.85,76.62 v1(131.85,77.84) ; Q14.1 123.82,80.62 124,80.43 124,78.58 v1(123.4,77.97) v2(123.4,75.79) 121.06,73.44 121.06,70.78 v1(120.09,69.82)
  IN2 w0.102: v1(37.64,79.16) 37.83,78.97 39.26,78.97 40.59,77.64 42.37,77.64 43.89,79.15 45.6,79.15 45.83,78.92 49.28,78.92 50.3,79.93 51.53,79.93 52.26,79.2 52.82,79.2 v1(53.28,79.66) 54.8,78.13 58.14,78.13 58.99,77.28 63.73,77.28 63.98,77.54 67.94,77.54 68.87,78.47 74.27,78.47 75.2,77.54 86.04,77.54 87.7,79.19 88.7,79.19 89.02,79.51 91.56,79.51 92.32,78.74 96.22,78.74 97.38,77.59 97.77,77.59 99.25,79.07 107.98,79.07 109.17,77.88 109.17,77.71 109.46,77.42 113.05,77.42 113.8,76.67 122.1,76.67 v1(123.4,77.97) 124.62,76.75 130.76,76.75 v1(131.85,77.84)
  IN3 w0.102: v1(101.98,72.22) 102.33,72.22 104.03,70.51 109.92,70.51 110.01,70.61 113.76,70.61 114.83,69.54 117.5,69.54 117.78,69.82 v1(120.09,69.82)
  BOTTOM w0.102: PR14.1 PR16.1 37.2,82.35 38.01,82.35 38.43,81.93 38.43,80.92 37.64,80.13 v1(37.64,79.16) ; PR11.1 50.87,72.89 52.93,74.95 52.93,77.15 53.09,77.31 53.49,77.31 53.8,77.61 53.8,79.34 53.48,79.66 v1(53.28,79.66) ; SC3.1 101.08,71.86 101.48,71.86 101.84,72.22 v1(101.98,72.22) 101.98,72.38 102.25,72.65 102.25,73.01 102.18,73.08 U10.124
PM_RSMRST#: length 96.3
  TOP w0.102: v1(51.06,74.06) 50.59,74.53 50.59,74.89 50.9,75.21 51.58,75.21 53.71,77.34 53.71,80.54 54.85,81.68 56.51,81.68 59.06,84.23 59.91,84.23 60.18,84.5 66.12,84.5 67.47,85.84 72.07,85.84 72.51,86.29 77.83,86.29 78.75,85.37 78.75,84.27 78.63,84.14 v1(78.63,83.15) ; v2(103.43,69.11) 104.04,69.11 v1(104.34,68.8)
  IN1 w0.127: v1(104.34,68.8) 103.81,68.8 102.74,69.86 102.74,70.05 99.51,73.28 99.51,74.7 98.15,76.06 97.03,76.06 95.03,78.05 95.03,78.6 94.03,79.6 93.45,79.6 92.74,78.88 91.63,78.88 91.13,79.38 88.98,79.38 88.82,79.21 87.73,79.21 86.08,77.56 85.29,77.56 83.82,79.04 83.33,79.04 81.39,80.98 79.85,80.98 78.63,82.2 v1(78.63,83.15)
  BOTTOM w0.089: 47.75,68.62 47.58,68.44 47.58,67.41 47.2,67.04 47.2,65.25 46.46,64.51 45.21,64.51 44.84,64.14 42.87,64.14 42.58,64.43 U1.AW6
  BOTTOM w0.102: PR18.1 52.09,74.43 51.72,74.06 v1(51.06,74.06) 50.47,73.47 50.25,73.47 49.91,73.14 49.91,71.87 50.04,71.75 50.04,70.91 47.75,68.62 ; R177.2 106.5,70.12 106.5,69.74 106.15,69.38 104.93,69.38 v1(104.34,68.8)
