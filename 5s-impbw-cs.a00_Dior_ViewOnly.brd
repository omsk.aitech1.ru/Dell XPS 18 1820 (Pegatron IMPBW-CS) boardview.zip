# Allegro board 5s-impbw-cs.a00_Dior_ViewOnly.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAD0_TPM: length 2.9
  TOP w0.102: U9.26 v2(130.87,33.8) 130.87,33.37 130.81,33.3 R166.1
LAD1: length 147.4
  TOP w0.102: v1(80.32,75.9) 79.08,74.66 77.78,74.66 77.03,75.4 67.72,75.4 66.96,74.64 64.44,74.64 63.91,74.11 62.85,74.11 62.59,73.85 60.38,73.85 58.68,72.15 58.68,71.19 57.67,70.17 57.67,61.5 57.04,60.87 v1(57.04,60.57) ; v1(90.93,75.3) 91.15,75.3 92.39,76.55 93.12,76.55 93.52,76.95 93.7,76.95 94.88,78.14 94.88,78.46 R182.1 ; R167.2 v1(129.09,30.47) v2(129.62,29.94)
  IN1 w0.127: v1(129.09,30.47) 127.18,32.38 109.48,32.38 98,43.86 97.23,43.86 94.81,46.28 94.81,47.9 95.79,48.89 95.79,62.01 97.64,63.85 97.64,67.93 95.78,69.78 95.78,71.95 93.58,74.16 93.58,75.68 92.72,76.54 92.29,76.54 91.06,75.3 v1(90.93,75.3)
  IN3 w0.102: v1(90.93,75.3) 90.84,75.3 89.99,76.15 89.61,76.15 89.45,76 83.14,76 82.58,76.55 80.98,76.55 v1(80.32,75.9)
  BOTTOM w0.089: 47.75,61.39 44.83,61.39 44.42,60.97 43.01,60.97 42.73,60.68 U1.AW12
  BOTTOM w0.102: v1(57.04,60.57) 57.03,60.57 56.58,61.02 56.12,61.02 55.75,61.39 47.75,61.39
LAD1_EC: length 29.1
  TOP w0.102: v1(87.56,80.41) 87.01,79.86 87.01,78.05 87.27,77.79 87.63,77.79 87.96,77.46 CON5.4 ; R182.2 96.38,78.72 96.8,78.3 96.8,77.65 97.03,77.42 97.03,77.19 97.29,76.93 98.17,76.93 v2(98.63,77.39) 99.48,78.24 v1(100.52,78.24)
  IN1 w0.127: v1(100.52,78.24) 99.77,78.24 99.19,77.66 97.29,77.66 96.38,78.57 96.38,79.54 94.14,81.78 92.73,81.78 91.89,80.94 88.09,80.94 v1(87.56,80.41)
  BOTTOM w0.102: v1(100.52,78.24) 100.52,78.52 100.1,78.93 U10.9
LAD1_TPM: length 2.9
  TOP w0.102: U9.23 v2(128.92,33.88) 128.92,33.57 129.09,33.4 R167.1
LAD2: length 145.1
  TOP w0.102: v1(92.54,76.1) 93.08,76.1 93.58,76.6 94.29,76.6 R183.1 ; v2(126.54,28.39) 126.54,29.98 v1(127.23,30.67) R169.2 ; v1(79.05,75.89) 78.33,75.16 77.99,75.16 77.24,75.91 67.51,75.91 66.75,75.15 64.23,75.15 64.03,74.95 60.76,74.95 58.18,72.36 58.18,71.4 57.16,70.38 57.16,68.81 56.33,67.97 56.33,60.83 v1(56.09,60.6)
  IN1 w0.127: v1(92.54,76.1) 93.3,75.35 93.3,74.05 95.51,71.84 95.51,69.67 97.36,67.81 97.36,63.97 95.51,62.12 95.51,49 94.53,48.02 94.53,44.47 99.11,39.9 100.63,39.9 103.86,36.67 103.86,35.28 106.07,33.07 107.46,33.07 108.28,32.25 108.43,32.1 125.44,32.1 126.87,30.67 v1(127.23,30.67)
  IN3 w0.102: v1(92.54,76.1) 92.22,75.79 90.72,75.79 90.06,76.45 89.55,76.45 89.35,76.25 83.25,76.25 82.69,76.81 79.94,76.81 79.71,76.57 79.33,76.19 79.33,76.17 v1(79.05,75.89)
  BOTTOM w0.089: U1.AY12 43.24,60.78 44.51,60.78 44.86,61.13 47.75,61.13
  BOTTOM w0.102: 47.75,61.13 55.56,61.13 v1(56.09,60.6)
LAD2_EC: length 33
  TOP w0.102: v1(86.92,80.41) 86.76,80.24 86.76,77.94 86.96,77.74 CON5.6 ; R183.2 96.38,77.71 96.78,77.31 96.78,77.08 97.18,76.67 98.78,76.67 99.8,77.69 101.37,77.69 101.5,77.56 v2(102.31,77.56) 102.31,78.02 102.09,78.24 v1(101.8,78.24)
  IN1 w0.127: v1(86.92,80.41) 87.53,81.02 87.77,81.02 87.99,81.23 91.79,81.23 92.62,82.06 94.25,82.06 96.7,79.61 96.7,79.18 97.35,78.53 100.2,78.53 100.35,78.68 101.37,78.68 v1(101.8,78.24)
  BOTTOM w0.102: v1(101.8,78.24) 101.38,77.82 100.34,77.82 99.62,78.53 U10.8
LAD2_TPM: length 3
  TOP w0.102: R169.1 127.23,33.14 127.12,33.25 v2(127.12,33.86) 127.12,34.46 126.97,34.61 U9.20
LAD3: length 141.8
  TOP w0.102: v1(81.92,75.63) 81.28,74.99 80.49,74.99 79.65,74.15 77.57,74.15 76.82,74.9 67.93,74.9 66.54,73.5 64.7,73.5 64.62,73.58 63.04,73.58 62.8,73.34 60.59,73.34 59.19,71.94 59.19,70.98 58.18,69.96 58.18,60.81 v1(57.96,60.6) ; R185.1 94.87,76.32 94.87,75.95 93.39,74.46 92.16,74.46 92,74.63 91.58,74.63 v1(91.16,74.21) ; R170.2 v1(123.98,30.58) 124.67,29.89 v2(125.4,29.89)
  IN1 w0.127: v1(91.16,74.21) 91.96,73.41 92.01,73.41 92.97,72.46 93.42,72 93.97,71.46 93.97,71.46 94.23,71.21 94.23,71.2 94.44,70.99 94.44,69.94 96.8,67.58 96.8,64.2 94.96,62.35 94.96,49.23 93.97,48.25 93.97,44.04 98.68,39.34 100.4,39.34 103.3,36.44 103.3,35.04 105.83,32.51 107.22,32.51 108.05,31.69 108.2,31.54 123.02,31.54 v1(123.98,30.58)
  IN3 w0.102: v1(81.92,75.63) 82.2,75.63 82.59,75.23 86.35,75.23 87.26,74.32 91.05,74.32 v1(91.16,74.21)
  BOTTOM w0.089: U1.AW11 42.78,61.15 44.34,61.15 44.83,61.64 47.75,61.64
  BOTTOM w0.102: 47.75,61.64 55.9,61.64 56.26,61.28 57.28,61.28 v1(57.96,60.6)
LAD3_EC: length 29.8
  TOP w0.102: v1(85.39,80.3) 85.39,78.84 85.96,78.27 CON5.8 ; R185.2 97.18,76.19 97.18,76.17 v2(97.39,75.96) 98.53,75.96 99.97,77.41 100.4,77.41 v1(100.83,76.98)
  IN1 w0.127: v1(85.39,80.3) 86,79.7 88.54,79.7 88.92,80.08 94.23,80.08 95.52,78.8 95.52,78.25 97.21,76.56 100.4,76.56 v1(100.83,76.98)
  BOTTOM w0.102: v1(100.83,76.98) 100.24,77.57 100.18,77.57 99.61,78.13 U10.7
LAD3_TPM: length 3.3
  TOP w0.102: R170.1 123.98,33.57 v2(124.26,33.85) 125.02,34.61 U9.17
LCD_BACKOFF_EC#: length 128.7
  TOP w0.102: v2(173.99,20.01) 173.02,19.03 R293.2 v1(171.91,18.6)
  IN2 w0.102: v1(105.86,82.34) 106.5,82.34 106.91,82.74 109.48,82.74 109.73,82.49 109.73,82.18 110.49,81.42 115.99,81.42 116.24,81.16 119.91,81.16 120.52,81.77 126.43,81.77 126.7,82.04 142.59,82.04 143.88,80.75 143.88,79.85 147.63,76.11 147.63,67.81 152.83,62.6 152.83,45 160.05,37.79 164.25,37.79 172.12,29.91 172.12,18.81 v1(171.91,18.6)
  BOTTOM w0.102: U10.57 110.18,88.99 109.87,88.68 109.53,88.68 109.09,88.24 109.09,86.56 106.43,83.89 106.43,82.9 v1(105.86,82.34)
LCD_BKEN_PCH: length 122
  TOP w0.089: v2(19.28,62.37) 18.72,62.37 v1(18.53,62.55)
  IN2 w0.089: 16.26,71.26 16.26,70
  IN2 w0.102: v1(18.53,62.55) 18.49,62.6 18.49,63.26 18.77,63.54 18.88,63.54 19.36,64.02 19.36,67.93 18,69.28 16.97,69.28 16.26,70 ; v1(103.77,84.6) 103.21,85.16 100.7,85.16 99.92,84.38 96.87,84.38 96.16,85.08 93.86,85.08 93.12,84.33 88.27,84.33 87.73,83.79 85.95,83.79 85.44,84.29 84.28,84.29 83.77,84.8 83.77,85.42 83.47,85.72 78.36,85.72 78.08,86 67.34,86 66.52,85.18 65.55,85.18 65.06,84.69 61.62,84.69 61.31,84.38 55.98,84.38 55.73,84.63 51.96,84.63 51.45,85.14 47.19,85.14 46.54,84.49 40.93,84.49 40.27,85.15 38.08,85.15 37,84.07 31.51,84.07 31.36,83.92 26.48,83.92 24.14,81.57 22.12,81.57 19.25,78.71 18.19,78.71 15.77,76.3 15.77,74.09 16.26,73.61 16.26,71.26
  BOTTOM w0.089: v1(18.53,62.55) 18.61,62.63 19.1,62.63 19.26,62.47 20.39,62.47 U1.A9
  BOTTOM w0.102: v1(103.77,84.6) 103.77,86 104.28,86.52 104.92,86.52 105.16,86.76 105.16,87.54 105.32,87.7 105.72,87.7 106.4,88.38 106.4,88.68 106.58,88.87 U10.48
LCD_BL_PWM: length 159.1
  TOP w0.102: v2(152.55,78.22) 152.55,79.93 152.22,80.26 v1(152.22,85.11) ; R288.2 v1(174.21,19.21) ; v1(130.94,87.6) 130.94,89.32 129.61,90.65 97.98,90.65 95.78,88.46 v1(95.78,88.41)
  IN2 w0.102: v1(130.94,87.6) 131.38,88.04 149.41,88.04 151.07,86.38 151.07,84.93 151.33,84.68 151.79,84.68 v1(152.22,85.11)
  IN3 w0.102: v1(152.22,85.11) 152.22,84.68 152.66,84.24 157.71,84.24 157.86,84.09 163.37,84.09 164.42,83.04 164.42,82.4 168.53,78.29 168.53,72.94 167.9,72.31 167.9,49.36 169.65,47.61 169.65,45.09 170.42,44.31 170.42,42.42 v1(169.37,41.37)
  BOTTOM w0.102: v1(169.37,41.37) 169.79,41.79 170.38,41.79 172.8,39.37 172.8,35.13 173.38,34.55 173.38,32.74 174.87,31.26 174.87,19.87 v1(174.21,19.21) ; U10.30 97.9,87.33 97.61,87.62 96.83,87.62 96.24,88.21 96.24,88.67 96.29,88.71 CB7.1 96.09,89.07 95.78,88.76 v1(95.78,88.41)
LCD_BL_PWM_C: length 47.7
  TOP w0.102: 164.21,15.56 v1(164.25,15.56) ; 164.21,15.56 164.25,15.6 R286.1 ; 164.21,15.56 v2(163.54,15.56) ; R288.1 174.59,17.76 174.98,17.37 174.98,16.25 R289.1 v1(174.21,14.74)
  IN3 w0.102: v1(164.25,15.56) 164.31,15.63 169.13,15.63 170.16,14.59 174.06,14.59 v1(174.21,14.74) 174.21,16.13 175.52,17.44 175.52,28.24 179.03,31.75 179.03,33.74 v1(181.29,36)
  BOTTOM w0.102: v1(164.25,15.56) 164.75,15.06 P2.35 ; VU3.4 v1(181.29,36)
LCD_VDD_EN_EC: length 118.4
  TOP w0.102: v2(145.46,83.99) v1(145.46,83.2)
  IN1 w0.102: v1(111.65,82.65) 112.13,82.17 113.92,82.17 114.62,82.87 126.68,82.87 127.39,83.58 143.25,83.58 144.04,82.79 145.06,82.79 v1(145.46,83.2)
  IN3 w0.102: v1(169.24,43.65) 168.58,44.31 168.58,47.79 167.29,49.09 167.29,72.59 167.92,73.23 167.92,78.04 163.89,82.07 158.7,82.07 157.15,83.62 145.89,83.62 v1(145.46,83.2)
  BOTTOM w0.102: R297.2 177.5,34.64 176.53,35.6 176.53,36.49 175.9,37.13 175.9,38.08 175.37,38.6 174.3,38.6 173.61,39.29 173.61,39.71 171.25,42.07 171.25,42.66 170.25,43.65 v1(169.24,43.65) ; v1(111.65,82.65) 112.07,83.07 113.36,83.07 113.49,82.93 U10.78
LPC_FRAME#: length 147.3
  TOP w0.102: v1(79.69,75.9) 78.7,74.91 77.89,74.91 77.14,75.66 67.62,75.66 66.86,74.9 64.34,74.9 63.8,74.36 62.74,74.36 62.48,74.1 60.28,74.1 58.43,72.26 58.43,71.29 57.42,70.28 57.42,68.7 56.58,67.87 56.58,60.49 56.26,60.18 55.88,60.18 v1(55.46,60.6) ; v2(128.58,28.44) 128.28,28.74 128.28,30.41 v1(128.1,30.59) R168.2 ; v1(91.82,74.21) 93.5,74.21 95.28,76 R186.1
  IN1 w0.127: v1(91.82,74.21) 92.69,74.21 93.42,73.48 93.7,73.2 94.49,72.41 94.9,72 94.9,69.88 97.08,67.7 97.08,64.08 95.24,62.24 95.24,49.12 94.25,48.13 94.25,44.16 98.79,39.62 100.52,39.62 103.58,36.55 103.58,35.16 105.95,32.79 107.34,32.79 108.16,31.97 108.31,31.82 123.51,31.82 123.93,31.4 125.74,31.4 126.93,30.22 127.72,30.22 v1(128.1,30.59)
  IN3 w0.102: v1(79.69,75.9) 80.11,75.48 81.13,75.48 81.7,76.04 82.37,76.04 82.93,75.49 87.66,75.49 88.57,74.58 89.69,74.58 89.74,74.63 91.4,74.63 v1(91.82,74.21)
  BOTTOM w0.089: 47.75,60.88 44.86,60.88 44.56,60.58 43.56,60.58 43.38,60.4 42.7,60.4 42.69,60.38 42.1,60.38 U1.AV12
  BOTTOM w0.102: v1(55.46,60.6) 55.17,60.88 47.75,60.88
LPC_FRAME#_EC: length 29.1
  TOP w0.102: v1(100.19,76.99) 100.19,76.46 v2(99.67,75.94) 99.16,75.43 96.95,75.43 R186.2 ; v1(85.38,80.93) 84.96,80.51 CON5.10
  IN1 w0.127: v1(85.38,80.93) 86.33,79.98 88.42,79.98 88.8,80.36 92.2,80.36 92.99,81.14 93.98,81.14 95.82,79.31 95.82,78.34 97.17,76.99 v1(100.19,76.99)
  BOTTOM w0.102: v1(100.19,76.99) 100.19,77.15 99.6,77.73 U10.6
LPC_FRAME#_TPM: length 6.1
  TOP w0.102: U9.22 128.27,34.65 128.1,34.48 R168.1 127.76,32.73 127.66,32.63 v2(127.66,29.94)
LRESET#: length 6.6
  TOP w0.102: v2(123.6,29.74) 123.5,29.84 123.5,32.26 R171.1 123.06,33.37 124.37,34.68 U9.16
LVDS_DET_CBL#: length 243.9
  TOP w0.102: v1(150.83,7.97) 150.32,7.46 R426.2 149.99,6.81 v2(149.99,6.06)
  IN1 w0.102: v1(150.83,7.97) 150.79,8.01 150.79,11.12 151.41,11.74 151.41,21.53 152.76,22.88 152.76,27.48 155.35,30.07 166.17,30.07 167.49,31.39 v1(167.49,36.87)
  IN2 w0.102: v1(24.92,70.18) 25.95,71.21 25.95,75.65 29.05,78.74 32.47,78.74 33.75,80.03 36.96,80.03 37.13,80.2 38,80.2 38.33,80.53 38.75,80.53 40.32,82.09 40.7,82.09 41.82,80.97 43.97,80.97 45.11,82.11 48.92,82.11 49.26,82.45 55.04,82.45 55.46,82.02 62.45,82.02 63.22,82.8 66.9,82.8 67.94,83.84 79.2,83.84 79.91,83.13 80.82,83.13 81.55,82.4 86.12,82.4 86.68,81.84 88.86,81.84 89.25,81.45 92.35,81.45 92.72,81.82 94.15,81.82 95.09,80.88 98.16,80.88 98.96,81.68 101.36,81.68 101.57,81.89 108.04,81.89 108.23,81.7 108.59,81.7 109.5,80.79 115.53,80.79 115.77,80.55 120.26,80.55 120.87,81.16 127,81.16 127.27,81.43 139.55,81.43 140.89,80.09 142.78,80.09 147.02,75.85 147.02,67.51 152.22,62.3 152.22,42.94 156.82,38.35 156.82,36.95 156.56,36.69 v1(155.93,36.69)
  BOTTOM w0.089: 24.7,69.38 24.7,68.89 25.48,68.1 25.48,68.08 25.49,68.08 U1.J1
  BOTTOM w0.102: v1(24.92,70.18) 24.7,69.95 24.7,69.38 ; v1(150.83,7.97) 150.75,8.04 P2.7 ; v1(155.93,36.69) 158.12,36.69 159.25,37.83 162.36,37.83 164.04,39.5 166.09,39.5 166.33,39.26 166.33,38.03 v1(167.49,36.87)
LVDS_L0N_NB: length 26.9
  TOP w0.102: 155.92,26.32 v2(155.71,26.51) ; 155.92,26.32 156.39,26.79 157.18,26.79 157.66,26.31 157.66,25.28 157.82,25.12 U6.19 ; 155.92,26.32 155.58,25.98 155.09,25.98 v1(154.89,26.18)
  IN3 w0.102: v1(154.89,26.18) 157.63,26.18 159.21,24.6 159.21,19.05 158.72,18.56 158.22,18.56 157.81,18.15 157.81,15.71 158.09,15.43 v1(158.09,12.36)
  BOTTOM w0.102: v1(158.09,12.36) 158.09,11.32 157.89,11.12 157.89,10.57 157.75,10.43 P2.21
LVDS_L0P_NB: length 26.8
  TOP w0.102: 157.25,25.32 v2(156.97,25.32) ; 157.25,25.32 157.25,25.11 157.65,24.72 U6.20 ; 157.25,25.32 157.25,26.14 157.01,26.38 156.56,26.38 155.74,25.57 155.04,25.57 v1(154.89,25.42)
  IN3 w0.102: v1(154.89,25.42) 155.25,25.77 157.47,25.77 158.8,24.44 158.8,19.22 158.55,18.97 158.05,18.97 157.41,18.32 157.41,15.54 157.68,15.26 157.68,12.72 v1(157.3,12.34)
  BOTTOM w0.102: v1(157.3,12.34) 157.68,11.96 157.68,11.49 157.48,11.29 157.48,10.74 157.13,10.38 157.13,10.08 157.25,9.95 P2.20
LVDS_L1N_NB: length 27
  TOP w0.102: 154.51,24.32 v2(154.51,24.6) ; 154.51,24.32 158.06,24.32 158.07,24.32 U6.21 ; 154.51,24.32 153.24,24.32 152.35,23.44 v1(151.9,23.44)
  IN3 w0.102: v1(156.47,11.02) 156.47,11.93 155.96,12.44 155.96,14.83 155.53,15.26 154.91,15.26 154.71,15.45 154.71,15.82 155.5,16.6 155.5,21.61 154.84,22.27 154.84,23.69 154.23,24.3 152.93,24.3 152.43,23.79 152.43,23.53 152.33,23.44 v1(151.9,23.44)
  BOTTOM w0.102: v1(156.47,11.02) 156.25,10.8 P2.18
LVDS_L1P_NB: length 27
  TOP w0.102: v1(151.89,22.75) 152.17,23.03 152.52,23.03 153.02,23.53 ; 153.02,23.53 v2(153.22,23.33) ; 153.02,23.53 153.41,23.92 U6.22
  IN3 w0.102: v1(151.89,22.75) 152.17,23.03 152.5,23.03 152.83,23.36 152.83,23.62 153.1,23.89 154.06,23.89 154.43,23.52 154.43,22.1 155.09,21.44 155.09,16.77 154.31,15.98 154.31,15.28 154.74,14.85 155.36,14.85 155.55,14.66 155.55,12.27 156.06,11.76 156.06,11.4 v1(155.68,11.02)
  BOTTOM w0.102: P2.17 155.75,9.67 155.55,9.87 155.55,10.05 155.65,10.15 155.78,10.15 155.84,10.22 155.84,10.85 v1(155.68,11.02)
LVDS_L2N_NB: length 30.8
  TOP w0.102: U6.23 157.91,23.52 157.91,23.52 155.17,23.52 154.29,22.65 152.87,22.65 150.95,20.73 150.95,18.2 ; 150.95,18.2 v2(150.67,18.2) ; 150.95,18.2 150.95,17.29 v1(150.88,17.21)
  IN3 w0.102: v1(150.88,17.21) 151.33,16.76 151.33,11.96 150.78,11.4 150.78,10.19 150.34,9.75 150.34,6.75 150.83,6.27 152.96,6.27 153.8,7.1 v1(154.84,7.1)
  BOTTOM w0.102: v1(154.84,7.1) 154.84,7.5 154.75,7.59 P2.15
LVDS_L2P_NB: length 30.8
  TOP w0.102: 151.36,19.91 151.36,20.57 153.04,22.24 154.46,22.24 155.33,23.12 U6.24 ; 151.36,19.91 151.36,17.04 v1(150.88,16.55) ; 151.36,19.91 v2(151.64,19.91)
  IN3 w0.102: v1(150.88,16.55) 150.93,16.5 150.93,12.12 150.37,11.56 150.37,10.36 149.94,9.92 149.94,6.58 150.66,5.86 153.13,5.86 153.97,6.7 154.33,6.7 v1(154.36,6.67)
  BOTTOM w0.102: P2.14 154.25,8.56 154.34,8.46 154.34,7.03 154.36,7.01 v1(154.36,6.67)
LVDS_LCDEN_B: length 11.4
  TOP w0.254: Q23.1 171.1,32.02 171.38,31.74 v2(176.68,31.74) 179.3,31.74 v1(180.16,32.61)
  BOTTOM w0.254: R302.2 v1(180.16,32.61)
LVDS_LCDEN_C: length 23.4
  TOP w0.102: v2(174.12,28.57) 174.12,29.25 173.4,29.97 v1(173.4,30.86)
  TOP w0.254: v1(170.65,15.23) R298.2 ; Q23.3 171.39,30.87 171.4,30.86 Q22.1 v1(173.4,30.86)
  IN1 w0.254: v1(170.65,15.23) 171.43,16.02 171.43,16.48 172.92,17.98 172.92,30.39 v1(173.4,30.86)
LVDS_LCLKN_NB: length 27.6
  TOP w0.102: 153.65,21.19 v2(153.44,21.38) ; 153.65,21.19 153.15,20.69 v1(152.73,20.69) ; 153.65,21.19 154.22,21.76 156.08,21.76 156.26,21.58 156.64,21.58 157.38,22.32 U6.26
  IN3 w0.102: v1(152.73,20.69) 153.72,20.69 154.18,20.24 154.18,18.2 152.88,16.91 152.88,11.95 153.26,11.57 154.31,11.57 154.66,11.22 154.66,9.67 154.05,9.06 152.05,9.06 151.84,8.86 v1(151.84,7.33)
  BOTTOM w0.102: P2.9 151.75,8.68 151.7,8.64 151.7,7.47 v1(151.84,7.33)
LVDS_LCLKP_NB: length 27.6
  TOP w0.102: 155.47,21.35 154.39,21.35 153.32,20.29 152.96,20.29 152.73,20.06 v1(152.57,20.06) ; 155.47,21.35 v2(155.47,21.07) ; 155.47,21.35 155.92,21.35 156.09,21.18 156.81,21.18 157.55,21.92 U6.27
  IN3 w0.102: v1(152.57,20.06) 152.73,20.06 152.96,20.29 153.55,20.29 153.77,20.07 153.77,18.37 152.48,17.08 152.48,11.78 153.09,11.17 154.14,11.17 154.26,11.05 154.26,9.84 153.88,9.47 151.88,9.47 151.44,9.02 151.44,7.56 v1(151.21,7.33)
  BOTTOM w0.102: v1(151.21,7.33) 151.3,7.42 151.3,8.64 151.25,8.68 P2.8
LVDS_U0N_NB: length 27.7
  TOP w0.102: v1(159.79,18.1) 160.09,18.4 U6.35
  IN1 w0.102: v1(162.23,11.4) 161.95,11.12 161.95,10.1 162.26,9.8 164.49,9.8 164.98,10.28 164.98,11.09 165.38,11.5 166.09,11.5 166.45,11.86 166.45,13.37 165.96,13.86 165.36,13.86 165.08,13.58 165.08,12.56 164.64,12.13 162.99,12.13 162.56,12.56 162.56,14.24 162.05,14.75 161.55,14.75 160.58,15.71 160.41,15.71 159.77,15.08 159.36,15.08 158.37,16.07 158.37,16.84 158.77,17.24 159.2,17.24 159.79,17.83 v1(159.79,18.1)
  BOTTOM w0.102: v1(162.23,11.4) 162.25,11.38 P2.30
LVDS_U0P_NB: length 27.7
  TOP w0.102: U6.36 160.49,18.17 v1(160.43,18.1)
  IN1 w0.102: v1(161.47,10.89) 161.7,10.66 161.7,10 162.16,9.54 164.59,9.54 165.23,10.18 165.23,10.99 165.49,11.24 166.19,11.24 166.7,11.75 166.7,13.48 166.07,14.11 165.25,14.11 164.82,13.68 164.82,12.67 164.54,12.39 163.1,12.39 162.82,12.67 162.82,14.34 162.16,15 161.65,15 160.69,15.97 160.3,15.97 159.67,15.33 159.46,15.33 158.62,16.17 158.62,16.73 158.88,16.98 159.31,16.98 v1(160.43,18.1)
  BOTTOM w0.102: v1(161.47,10.89) 161.84,10.51 161.84,9.95 161.75,9.85 P2.29
LVDS_U1N_NB: length 27.8
  TOP w0.102: v1(160.5,17.47) 160.89,17.86 U6.37
  IN1 w0.102: v1(160.71,12.45) 160.15,13.01 160.15,13.35 160.63,13.83 160.63,14.24 160.28,14.6 158.29,14.6 157.48,13.78 156.02,13.78 155.78,14.02 155.78,15 156.26,15.49 157.08,15.49 157.81,16.22 157.81,17.14 157.05,17.9 157.05,18.41 157.23,18.58 157.79,18.58 158.01,18.81 158.01,19.65 158.09,19.73 158.72,19.73 158.82,19.63 158.82,18.86 159.07,18.61 159.59,18.61 159.84,18.86 159.84,19.63 159.94,19.73 160.42,19.73 160.61,19.55 160.61,18.81 160.94,18.48 160.94,17.9 v1(160.5,17.47)
  BOTTOM w0.102: P2.27 160.75,9.95 160.58,10.12 160.58,11.22 160.3,11.5 160.3,12.04 v1(160.71,12.45)
LVDS_U1P_NB: length 27.8
  TOP w0.102: U6.38 161.29,17.65 v1(161.19,17.54)
  IN1 w0.102: v1(159.89,12.48) 159.89,13.46 160.38,13.94 160.38,14.14 160.17,14.34 158.4,14.34 157.58,13.53 155.91,13.53 155.53,13.92 155.53,15.11 156.16,15.74 156.97,15.74 157.56,16.33 157.56,17.03 156.8,17.79 156.8,18.51 157.12,18.84 157.68,18.84 157.76,18.92 157.76,19.75 157.99,19.98 158.83,19.98 159.08,19.73 159.08,18.97 159.18,18.86 159.48,18.86 159.59,18.97 159.59,19.73 159.84,19.98 160.53,19.98 160.86,19.65 160.86,18.91 161.19,18.58 v1(161.19,17.54)
  BOTTOM w0.102: v1(159.89,12.48) 159.89,11.33 160.17,11.05 160.17,9.95 160.25,9.88 P2.26
LVDS_U2N_NB: length 28.7
  TOP w0.102: v1(162.18,17.67) 162.26,17.75 162.26,18.17 162.09,18.33 U6.40
  IN1 w0.102: v1(162.18,17.67) 162.18,17.31 162.36,17.14 162.36,16.17 163.65,14.88 166.01,14.88 167.39,13.5 167.39,9.17 166.65,8.42 162.18,8.42 161.05,9.56 160.04,9.56 159.82,9.34 159.82,8.5 159.72,8.4 159.06,8.4 158.85,8.6 158.85,10.42 v1(159.46,11.03)
  BOTTOM w0.102: v1(159.46,11.03) 159.01,10.57 159.01,10.22 159.07,10.15 159.18,10.15 159.25,10.09 P2.24
LVDS_U2P_NB: length 28.7
  TOP w0.102: v1(162.79,17.16) 162.66,17.29 162.66,18.34 162.49,18.51 U6.41
  IN1 w0.102: v1(158.51,10.85) 158.51,10.47 158.6,10.38 158.6,8.5 158.95,8.15 159.82,8.15 160.07,8.4 160.07,9.23 160.14,9.31 160.94,9.31 162.08,8.17 166.75,8.17 167.64,9.06 167.64,13.61 166.12,15.13 163.76,15.13 162.61,16.27 162.61,16.98 v1(162.79,17.16)
  BOTTOM w0.102: P2.23 158.75,9.9 158.6,10.05 158.6,10.41 158.51,10.49 v1(158.51,10.85)
LVDS_UCLKN_NB: length 31.3
  TOP w0.102: U6.42 162.89,18.22 v1(163.35,17.76) ; v1(153.37,7.71) 153.27,7.82 153.27,8.58 154.48,9.8 ; C131.1 155.12,11.89 155.12,11.45 154.64,10.96 154.64,9.95 154.48,9.8 ; 154.48,9.8 v2(154.68,9.6)
  IN1 w0.102: v1(153.37,7.71) 153.24,7.84 153.24,11.57 154.18,12.51 154.18,15.49 156.29,17.59 156.29,19.37 157.56,20.64 160.91,20.64 161.37,20.18 161.37,19.14 162.41,18.1 163.03,18.1 163.35,17.78 v1(163.35,17.76)
  BOTTOM w0.102: v1(153.37,7.71) 153.37,8.54 153.25,8.66 P2.12
LVDS_UCLKP_NB: length 31.3
  TOP w0.102: 153.05,8.94 v2(152.85,9.14) ; 153.05,8.94 152.86,8.75 152.86,7.84 v1(152.73,7.71) ; 153.05,8.94 153.8,9.69 154.23,10.12 154.23,11.13 154.71,11.62 154.71,11.9 C130.1 ; v1(163.58,18.36) 163.3,18.63 163.3,19.06 U6.43
  IN1 w0.102: v1(152.73,7.71) 152.99,7.97 152.99,11.68 153.93,12.62 153.93,15.59 156.03,17.7 156.03,19.48 157.45,20.9 161.02,20.9 161.62,20.29 161.62,19.25 162.51,18.36 v1(163.58,18.36)
  BOTTOM w0.102: v1(152.73,7.71) 152.96,7.94 152.96,8.37 152.75,8.58 P2.11
M_A_B_DIMM_ODT: length 5.2
  TOP w0.102: HR14.1 HR15.1 64.24,64.53 64.26,64.51 HQ2.2 66.26,64.51 66.83,63.94 v2(66.83,63.26)
M_CHA_BA0: length 135
  TOP w0.102: U4.M2 80.44,54.7 80.44,55.3 80.71,55.56 v1(80.71,56.01) ; U3.M2 80.89,34.43 81.08,34.43 81.18,34.54 v1(81.18,34.94) ; U5.M2 80.78,65.59 80.49,65.3 80.27,65.3 80.16,65.4 80.16,65.58 80.32,65.74 80.32,66.24 80.43,66.34 80.72,66.34 80.78,66.29 v1(81.18,66.29) ; v1(81.21,24.25) 81.21,23.44 U2.M2
  TOP w0.267: v1(76.2,50.14) 75.95,50.14 R1.1
  IN1 w0.102: v1(81.18,34.94) 81.39,35.15 81.74,35.15 81.8,35.08 81.8,34.56 81.73,34.49 81.13,34.49 81.03,34.38 81.03,34 81.13,33.9 81.33,33.9 81.41,33.98 81.41,34.1 81.48,34.18 81.71,34.18 81.8,34.09 81.8,33.28 81.74,33.22 81.59,33.22 81.48,33.11 81.48,32.91 81.56,32.83 81.73,32.83 81.8,32.76 81.8,32.54 81.69,32.42 81.51,32.42 81.51,32.42 81.48,32.42 81.23,32.17 81.23,31.67 81.31,31.59 v1(81.31,30.9) 81.31,29.27 81.89,28.69 81.89,27.07 81.6,26.78 81.6,25.65 80.98,25.03 80.98,24.49 v1(81.21,24.25) ; v1(80.71,56.01) 81.24,56.01 81.52,56.29 81.52,58.65 82.55,59.68 82.55,61.14 v1(82.34,61.35) 82.34,61.75 82.04,62.04 82.04,63.03 80.77,64.3 80.77,65.88 v1(81.18,66.29)
  IN2 w0.089: v1(40.51,46.73) 40.67,46.58 43.21,46.58 43.56,46.93 43.56,47.91 43.44,48.03 43.44,48.69 44.1,49.34 44.48,49.34 46.46,51.33 49.51,51.33
  IN2 w0.33: 49.51,51.33 53.28,51.33 53.79,51.85 54.62,51.85 55.14,51.33 55.55,51.33 57.78,53.56 58.22,53.56 58.8,54.14 59.29,54.14 59.87,53.56 60.2,53.56 60.43,53.79 60.43,54.2 59.87,54.75 59.87,55.27 60.04,55.44 60.46,55.44 61.06,54.84 61.93,54.84 62.38,55.29 62.64,55.29 62.83,55.1 62.83,54.6 63.45,53.98 64.32,53.98 65.23,54.89 65.82,54.89 66.39,55.46 67.55,55.46 68.29,54.71 70.28,54.71 70.68,54.32 71.48,54.32 71.76,54.6 72.24,54.6 72.52,54.32 72.52,54.01 71.86,53.35 71.86,52.91 72.17,52.6 73.52,52.6 75.98,50.13 76.19,50.13 v1(76.2,50.14)
  BOTTOM w0.089: v1(40.51,46.73) 40.69,46.91 U1.AU35
  BOTTOM w0.102: v1(82.34,61.35) 82.34,61.85 82.04,62.15 82.04,62.98 81.92,63.11 v2(81.81,63.11) 81.73,63.11 81.6,62.98 81.6,62.16 81.75,62.01 81.75,61.37 81.97,61.16 81.97,60.9 82.07,60.8 82.48,60.8 82.56,60.72 82.56,60.09 82.46,59.99 81.99,59.99 81.89,59.89 81.89,59.38 81.38,58.87 80.89,58.87 80.74,59.02 80.52,59.02 80.43,58.94 80.43,58.21 80.53,58.11 81.12,58.11 81.22,58.01 81.22,57.64 80.98,57.4 80.98,57.27 81.22,57.03 81.22,56.75 81,56.53 81,56.32 81.48,55.84 81.61,55.71 81.61,54.44 81.51,54.34 81.03,54.34 80.92,54.23 80.92,53.67 81.03,53.57 81.5,53.57 81.6,53.47 81.6,52.02 81.48,51.91 81.26,51.91 81.08,52.09 80.85,52.09 78.84,50.08 76.51,50.08 76.44,50.14 v1(76.2,50.14) 74.78,48.72 74.67,48.72 74.42,48.47 74.42,44.27 74.92,43.77 76.78,43.77 79.02,41.53 79.02,40.84 80.09,39.77 80.09,38.86 80.57,38.38 80.57,35.82 81.01,35.39 81.33,35.39 81.62,35.1 81.62,32.53 81.26,32.18 81.26,31.41 81.31,31.36 v1(81.31,30.9)
M_CHA_BA1: length 136.2
  TOP w0.102: v1(82.68,26.28) 82.12,26.28 82.02,26.38 82.02,27.72 81.92,27.81 U2.N8 ; v1(82.05,68.41) 82.04,68.42 82.04,70.23 U5.N8 ; U3.N8 81.58,39.14 81.92,38.8 81.92,37.34 v1(82.05,37.22) ; U4.N8 81.58,59.42 81.68,59.52 81.94,59.52 82.04,59.42 82.04,58.64 81.92,58.52 81.92,57.9 82.03,57.8 v1(82.35,57.8)
  TOP w0.267: v1(77.07,48.75) 76.76,48.44 R2.1
  IN1 w0.102: v1(82.05,37.22) 82.37,37.55 82.37,37.74 82.2,37.91 81.7,37.91 81.6,37.81 81.6,37.04 81.84,36.8 82.25,36.8 82.41,36.63 82.41,33.44 v1(82.69,33.16) 83.13,32.73 83.13,31.66 82.9,31.43 82.9,26.5 v1(82.68,26.28) ; v1(82.05,68.41) 82.45,68.01 82.45,66.51 83.26,65.7 83.26,64.09 83.64,63.71 83.64,62.19 v1(83.4,61.94) 83.18,61.72 83.18,58.2 83.01,58.03 82.74,58.03 82.6,58.17 82.6,58.59 82.53,58.67 82.4,58.67 82.13,58.4 82.13,58.01 v1(82.35,57.8)
  IN2 w0.089: 44.88,47.69 44.88,47.52 v1(43.74,46.37)
  IN2 w0.33: v1(77.07,48.75) 76.79,49.03 76.52,49.03 76.23,48.73 75.9,48.73 73.08,51.55 72.67,51.55 72.47,51.35 72.24,51.35 72.04,51.55 70.89,51.55 70.85,51.51 70.84,51.51 70.68,51.35 70.41,51.35 70.26,51.5 70.26,52.24 70.09,52.4 69.93,52.4 69.92,52.42 68.84,52.42 68.66,52.6 68.66,52.76 68.48,52.94 67.57,52.94 67.39,53.12 67.39,54.14 67.13,54.4 66.8,54.4 66.6,54.2 66.6,52.98 66.16,52.54 65.91,52.54 65.74,52.72 65.74,53.26 65.56,53.43 65.25,53.43 64.73,52.92 64.73,51.99 64.55,51.81 63.85,51.81 63.67,51.99 63.67,52.29 63.5,52.47 62.51,52.47 62.18,52.79 61.86,52.79 61.53,52.47 59.23,52.47 59.06,52.29 59.06,51.53 58.88,51.35 57.04,51.35 55.95,50.26 54.8,50.26 54.09,49.55 53.52,49.55 53.34,49.73 53.34,50.11 53.16,50.29 52.55,50.29 52.38,50.11 52.38,49.73 52.2,49.55 51.68,49.55 51.5,49.73 51.5,50.11 51.32,50.29 46.64,50.29 44.88,48.53 44.88,47.69
  BOTTOM w0.089: U1.AV35 41.61,46.96 41.51,46.85 41.51,46.61 41.61,46.5 42.55,46.5 42.7,46.66 43.21,46.66 43.5,46.37 v1(43.74,46.37)
  BOTTOM w0.102: v1(82.69,33.16) 82.69,34.96 83.31,35.58 83.31,36.93 83,37.24 83,37.54 81.69,38.85 81.69,43.22 81.59,43.32 80.32,43.32 80.21,43.43 80.21,43.91 80.32,44.01 v2(81.18,44.01) 81.59,44.01 81.69,44.11 81.69,44.77 81.28,45.18 79.3,45.18 79.19,45.28 79.19,45.53 79.09,45.64 78.89,45.64 78.79,45.53 78.79,45.28 78.69,45.18 77.98,45.18 77.75,45.41 77.75,47.46 77.07,48.15 v1(77.07,48.75) 77.39,49.07 77.62,49.07 77.73,48.97 77.73,48.43 77.83,48.33 78.11,48.33 78.21,48.43 78.21,48.97 78.31,49.07 80.58,49.07 80.88,49.37 80.88,50.74 80.98,50.84 82.35,50.84 82.48,50.84 82.58,50.94 82.58,51.93 82.68,52.04 83.2,52.04 83.3,52.14 83.3,53.46 83.2,53.56 82.6,53.56 82.5,53.66 82.5,55.68 81.84,56.34 81.84,58.13 81.95,58.23 83.07,58.23 83.17,58.34 83.17,58.56 83.07,58.67 82.45,58.67 82.35,58.77 82.35,58.97 82.45,59.07 83.07,59.07 83.17,59.17 83.17,61.34 83.4,61.57 v1(83.4,61.94)
M_CHA_BA2: length 136.3
  TOP w0.102: U5.M3 80.75,66.72 80.75,68.65 v1(80.98,68.87) ; U2.M3 80.78,24.46 81.18,24.86 v1(81.42,24.86) ; v1(81.17,37.77) 81.17,38.11 81.07,38.21 80.85,38.21 80.75,38.11 80.75,37.63 80.57,37.46 80.57,36.82 80.78,36.61 80.78,36 80.76,35.98 80.76,35.36 U3.M3 ; U4.M3 81.17,55.54 v1(81.17,55.56)
  TOP w0.267: v1(84.6,44.54) 84.6,44.9 R3.1
  IN1 w0.102: v1(81.17,55.56) 81.79,55.56 81.89,55.47 81.89,54.75 82.02,54.63 83.03,54.63 83.14,54.73 83.14,55.26 83.06,55.34 82.53,55.34 82.43,55.44 82.43,55.9 82.55,56.02 83.35,56.02 83.8,56.47 83.8,59.44 84.46,60.11 84.46,60.98 v1(84.66,61.18) 84.9,61.42 84.9,62.87 84.48,63.29 84.48,64.17 84.04,64.61 84.04,67.26 82.43,68.87 v1(80.98,68.87) ; v1(81.42,24.86) 81.86,24.42 82.85,24.42 83.95,25.52 83.95,28.9 84.16,29.12 84.16,30.23 84.37,30.44 84.37,32.82 v1(84.13,33.06) 83.89,33.3 83.89,36.12 82.68,37.32 82.68,37.87 82.13,38.42 81.31,38.42 81.17,38.28 v1(81.17,37.77)
  IN2 w0.089: v1(43.84,42.69) 44.34,42.19 46.75,42.19 48.41,40.53 49.51,40.53
  IN2 w0.33: 49.51,40.53 50.37,40.53 55.89,35.01 59.67,35.01 60.35,35.69 60.35,36.1 60.53,36.28 61.83,36.28 62.85,37.29 63.29,37.29 64.17,36.42 67.33,36.42 69.04,38.13 69.04,41.98 69.74,42.68 73.05,42.68 73.68,43.31 75.61,43.31 76.26,43.96 84.02,43.96 v1(84.6,44.54)
  BOTTOM w0.089: U1.AY41 43.47,43.06 v1(43.84,42.69)
  BOTTOM w0.102: v1(84.66,61.18) 84.45,60.96 84.45,60.09 84.13,59.77 84.13,54.29 84.83,53.6 84.83,52.95 84.57,52.7 84.57,45.8 v2(84.3,45.53) 84.3,44.83 v1(84.6,44.54) 84.3,44.24 84.3,41.22 84.2,41.11 84.2,38.09 84.55,37.75 84.55,37.05 84.45,36.95 84.02,36.95 83.92,36.85 83.92,36.62 84.02,36.52 84.45,36.52 84.55,36.42 84.55,36.16 84.45,36.06 84.02,36.06 83.92,35.96 83.92,35.7 84.02,35.6 84.45,35.6 84.55,35.5 84.55,35.3 84.45,35.2 83.84,35.2 83.73,35.09 83.73,34.89 83.84,34.79 84.45,34.79 84.55,34.69 84.55,34.49 84.45,34.38 83.84,34.38 83.73,34.28 83.73,34 83.84,33.9 84.45,33.9 84.55,33.8 84.55,33.6 84.45,33.49 83.84,33.49 83.73,33.39 83.73,33.2 83.87,33.06 v1(84.13,33.06)
M_CHA_CAS#: length 131.1
  TOP w0.102: v1(79.1,24.5) 79.18,24.42 U2.K3 ; U3.K3 79.29,35.45 79.29,36.17 v1(79.61,36.49) ; v1(78.79,55.56) 79.03,55.8 79.17,55.8 79.43,55.54 79.43,55.4 U4.K3 ; U5.K3 79.18,67.38 v1(79.61,67.8)
  TOP w0.267: R7.1 80.82,49.14 v1(80.43,49.53)
  IN1 w0.102: v1(79.61,67.8) 79.16,67.36 79.16,64.49 79.91,63.74 79.91,62.32 80,62.24 80,61.5 v1(80.42,61.08) 80,60.66 80,58.59 79.76,58.34 79.36,58.34 79.07,58.06 79.07,56.52 79.21,56.38 79.21,55.98 v1(78.79,55.56) ; v1(79.61,36.49) 79.61,37.53 79.51,37.63 79.17,37.63 79.07,37.53 79.07,36.27 79.29,36.06 79.29,35.71 79.16,35.58 79.16,32.28 v1(79.31,32.13) 79.31,31.73 79.19,31.61 79.19,28.45 80.04,27.6 80.04,26.61 79.33,25.9 79.33,24.73 v1(79.1,24.5)
  IN2 w0.089: 49.29,51.85 46.43,51.85 45.11,50.54 44.12,50.54 43.09,49.51 43.09,48.09 43.36,47.82 43.36,47.06 43.08,46.78 42.12,46.78 v1(41.51,47.39)
  IN2 w0.33: v1(80.43,49.53) 80.08,49.88 77.73,49.88 76.81,50.79 76.06,50.79 74.63,52.22 74.63,52.44 75.19,53 75.19,53.56 73.41,55.34 72.82,55.34 72.57,55.08 71.6,55.08 71.34,54.83 70.9,54.83 70.5,55.23 68.51,55.23 67.76,55.98 66.17,55.98 65.61,55.41 65.02,55.41 64.1,54.5 63.66,54.5 63.35,54.81 63.35,55.59 62.98,55.96 62.31,55.96 61.72,55.36 61.27,55.36 60.68,55.96 60.33,55.96 59.84,56.46 59.44,56.46 59.1,56.12 59.1,55.05 58.8,54.75 57.35,54.75 57.08,54.47 57.08,53.6 55.85,52.37 53.58,52.37 53.06,51.85 49.29,51.85
  IN3 w0.102: v1(80.42,61.08) 80.84,60.66 80.84,60.15 80.32,59.63 80.32,59.25 80.6,58.97 83.52,58.97 83.62,58.87 83.62,56.86 84.22,56.27 84.22,54.75 84.32,54.65 84.69,54.65 84.79,54.55 84.79,53.66 84.69,53.56 84.09,53.56 83.99,53.46 83.99,52.81 84.09,52.71 84.56,52.71 84.66,52.61 84.66,51.43 84.56,51.33 80.65,51.33 80.43,51.1 v1(80.43,49.53) 80.43,48.85 81.32,47.96 81.32,47.1 81.55,46.87 81.55,42.23 80.71,41.39 80.71,33.8 80.28,33.36 80.28,32.56 80.57,32.27 80.57,31.92 80.33,31.68 79.96,31.68 79.78,31.86 79.58,31.86 v1(79.31,32.13)
  BOTTOM w0.089: U1.AU34 41.19,47.7 v1(41.51,47.39)
  BOTTOM w0.102: v2(79,68.19) 79.38,67.8 v1(79.61,67.8)
M_CHA_CKE0: length 137
  TOP w0.102: U5.K9 79.58,71.09 v1(79.58,71.08) ; U2.K9 79.18,28.72 v1(79.66,29.2) ; v1(79.58,60.35) 80,60.77 80,62.04 79.75,62.29 79.41,62.29 79.01,61.89 79.01,61.24 78.92,61.15 78.92,60.2 78.72,60.01 78.72,59.66 78.8,59.58 79.07,59.58 79.18,59.69 U4.K9 ; U3.K9 79.18,39.83 78.77,39.41 78.77,39.24 78.47,38.94 v1(77.98,38.94)
  TOP w0.267: v1(79.55,42.18) 78.82,42.92 R5.1
  IN2 w0.089: 49.51,38.14 46.89,40.76 43.48,40.76 43.25,40.99 43.25,41.21 42.98,41.48 41.91,41.48 v1(41.49,41.06)
  IN2 w0.33: 49.51,38.14 55.85,31.79 60.02,31.79 60.43,31.39 63.71,31.39 64.7,32.38 66.58,32.38 68.11,33.9 69.06,33.9 70.23,35.07 70.23,35.58 71.76,37.11 72.61,37.11 74.04,38.55 74.04,38.95 74.57,39.47 75.9,39.47 76.3,39.87 76.3,41.49 77,42.18 v1(79.55,42.18)
  IN3 w0.102: v1(80.33,62.5) 80.33,62.3 80,61.96 80,59.02 81.64,57.39 81.64,54.2 80.72,53.29 80.72,52.12 79.68,51.08 79.68,50.69 79.53,50.54 79.53,42.21 v1(79.55,42.18) 79.86,42.18 80.38,42.7 80.38,46.81 80.48,46.91 80.79,46.91 81.04,46.66 81.04,42.44 80.2,41.6 80.2,41.51 80.19,41.5 80.19,38.63 79.65,38.08 79.65,37.73 80.33,37.05 80.33,33.7 80.08,33.45 80.08,32.17 v1(80.15,32.09)
  BOTTOM w0.089: v1(41.49,41.06) 41.49,41.23 U1.AU43
  BOTTOM w0.102: v1(79.66,29.2) 79.66,28.49 79.91,28.24 80.57,28.24 81.05,28.72 81.05,29.1 80.66,29.5 80.14,29.5 80.04,29.6 80.04,29.8 80.14,29.9 80.66,29.9 80.76,30 80.76,30.21 80.66,30.31 80.14,30.31 80.04,30.41 80.04,30.61 80.14,30.72 80.66,30.72 80.76,30.82 80.76,31.02 80.66,31.12 80.14,31.12 80.04,31.22 80.04,31.43 80.14,31.53 80.66,31.53 80.76,31.63 80.76,31.99 80.66,32.09 v1(80.15,32.09) 80.15,32.5 80.28,32.63 80.28,33.46 80.34,33.52 80.34,35.12 80.05,35.41 78.75,35.41 78.67,35.49 78.06,35.49 77.81,35.74 77.81,38.78 v1(77.98,38.94) ; v1(79.58,60.35) 79.94,60 80.59,60 80.84,60.24 80.84,61.99 v1(80.33,62.5) 80.65,62.81 80.65,64.56 80.42,64.78 80.42,66.21 80.81,66.61 80.81,67.56 80.42,67.95 v2(80.42,69.54) 80.42,70.8 80.14,71.08 v1(79.58,71.08)
M_CHA_CKE1: length 133.2
  TOP w0.102: v1(77.98,39.74) 77.98,40.04 78.08,40.14 U3.J9 ; U5.J9 77.98,71.09 v1(77.98,71.09) ; v1(77.34,29.43) 77.6,29.68 77.87,29.68 77.97,29.58 77.97,29.02 U2.J9 ; v1(77.96,60.44) 77.29,60.44 77.19,60.54 77.19,60.85 77.29,60.95 78.51,60.95 78.61,60.85 78.61,60.19 U4.J9
  TOP w0.267: v2(75.97,43.81) 76.13,43.65 R25.1 77.74,42.17 v1(77.22,41.65)
  IN1 w0.102: v1(77.98,39.74) 78.36,39.74 78.66,39.44 78.66,36.72 78.27,36.33 78.06,36.33 77.81,36.08 77.81,35.7 78.42,35.09 78.42,33.37 v1(78.21,33.16) 77.78,32.73 77.78,31.56 77.67,31.46 76.35,31.46 76.15,31.26 76.15,30.62 76.3,30.47 77.12,30.47 77.34,30.24 v1(77.34,29.43) ; v1(77.98,71.09) 77.98,69.59 77.43,69.04 77.43,63.81 77.92,63.32 v1(77.92,62.72) 76.79,62.72 76.63,62.57 76.63,62.32 76.73,62.22 77.8,62.22 77.97,62.06 77.97,60.45 v1(77.96,60.44)
  IN2 w0.089: 49.51,37.4 49.21,37.7 49.21,38.14 46.77,40.58 43.31,40.58 v1(42.83,41.06)
  IN2 w0.33: v1(77.22,41.65) 77.22,36.79 76.84,36.42 75.21,36.42 74.58,35.78 72.58,35.78 72.32,35.52 72.32,34.27 72.13,34.07 70.25,34.07 69.22,33.04 68.05,33.04 67.72,32.71 67.72,31.44 67.29,31.01 66.93,31.01 66.69,31.25 66.69,31.6 66.45,31.84 65.67,31.84 65.37,31.54 65.37,31.03 65.12,30.78 60.3,30.78 59.81,31.27 55.64,31.27 49.51,37.4
  IN3 w0.102: v1(77.92,62.72) 77.92,61.93 77.97,61.89 77.97,61.54 77.34,60.92 77.34,58.39 78.26,57.47 78.26,57.07 77.55,56.36 77.51,56.36 77.22,56.07 77.22,53.61 77.5,53.33 77.5,46.45 77.34,46.3 77.34,41.77 v1(77.22,41.65) 77.04,41.47 76.81,41.47 76.68,41.6 76.68,42.92 76.58,43.02 76.27,43.02 76.16,42.92 76.16,41.09 76.32,40.94 77.17,40.94 77.24,40.86 77.24,40.53 77.14,40.43 76.06,40.43 75.96,40.33 75.96,40 76.06,39.9 77.14,39.9 77.24,39.79 77.24,39.46 77.14,39.36 76.06,39.36 75.96,39.26 75.96,38.63 76.06,38.52 77.14,38.52 77.24,38.42 77.24,36.4 77.14,36.3 75.3,36.3 75.2,36.2 75.2,35.47 75.3,35.37 76.95,35.37 77.06,35.27 77.06,33.27 77.16,33.16 v1(78.21,33.16)
  BOTTOM w0.089: U1.AW43 42.83,41.14 v1(42.83,41.06)
M_CHA_CLK0: length 138
  TOP w0.216: v1(77.2,57.21) 77.2,57.3 77.62,57.73 78.23,57.73 78.38,57.87 U4.J7 ; U3.J7 78.65,38.54 78.82,38.37 78.82,37.92 78.49,37.58 v1(78.23,37.58) ; U5.J7 78.59,69.68 78.59,69.16 78.55,69.12 78.55,69.11 v1(78.36,68.92) ; U2.J7 78.58,26.81 78.67,26.81 78.84,26.63 78.84,26.36 78.72,26.23 78.31,26.23 v1(78.02,25.94)
  TOP w0.254: v1(71.15,50.77) 70.85,50.47 R27.1
  IN1 w0.254: v1(78.23,37.58) 77.53,37.58 77.13,37.19 77.13,34.96 76.63,34.46 76.63,33.95 76.96,33.62 77.17,33.62 77.32,33.47 77.32,33.23 76.68,32.59 v1(76.68,31.89) ; v1(76.89,61.71) 77.01,61.59 77.01,61.18 76.9,61.07 75.99,61.07 75.64,60.72 75.64,60.22 76.13,59.73 76.94,59.73 77.11,59.57 77.11,59.1 76.89,58.88 76.89,58.35 77.2,58.04 v1(77.2,57.21)
  IN2 w0.343: v1(71.15,50.77) 70.99,50.61 68.78,50.61 68.45,50.94 68.45,51.68 67.94,52.2 66.86,52.2 66.36,51.69 66.36,51.36 66.07,51.06 61.78,51.06 61.12,51.73 60.23,51.73 59.78,51.28 59.78,50.04 59.61,49.86 59.11,49.86 58.37,50.61 57.7,50.61 57.01,49.92 57.01,49.08 58.12,47.97 59.25,47.97 59.51,47.72 59.51,47.19 59.29,46.97 57.64,46.97 56.95,47.65 56.08,47.65 55.51,47.09 55.51,46.39 55.25,46.13 54.56,46.13 54.19,46.49 54.19,48.12 53.51,48.8 52.05,48.8 51.5,48.25 51.5,47.72 51.25,47.48 50.56,47.48 50.31,47.73 50.31,48.93 49.69,49.55 47.39,49.55 46.84,49 46.84,47.82 46.64,47.62 45.46,47.62 44.35,46.51 v1(44.35,46.37)
  IN3 w0.216: v1(78.36,68.92) 78.46,68.83 78.46,64.55 77.13,63.22 77.13,61.96 77.12,61.95 v1(76.89,61.71) ; v1(78.02,25.94) 77.99,25.97 77.99,29.89 77.77,30.1 77.04,30.1 76.53,30.61 76.53,30.98 76.84,31.3 76.84,31.74 v1(76.68,31.89)
  BOTTOM w0.089: v1(44.35,46.37) 44.35,46.12 44.43,46.04 44.73,46.04 44.78,45.99 44.78,45.63 44.24,45.09 42.27,45.09 42.19,45.18 42.19,45.58 42.11,45.66 41.99,45.66 41.84,45.51 U1.AV37
  BOTTOM w0.254: 71.32,49.24 71.32,47.95 72.19,47.09 72.19,41.45 72.75,40.89 73.07,40.89 73.69,40.27 73.69,39.92 72.98,39.21 72.98,37.78 73.85,36.91 74.7,36.91 74.96,36.65 74.96,36.44 74.47,35.95 74.47,34.13 74.93,33.67 75.76,33.67 76.15,34.05 76.89,34.05 77.05,33.9 77.05,32.97 76.8,32.72 76.8,32.01 v1(76.68,31.89) ; 71.32,49.24 71.32,50.59 v1(71.15,50.77) 71.35,50.97 71.35,53.58 72.57,54.8 74.35,54.8 74.93,54.23 74.93,53.33 75.2,53.06 76.49,53.06 77.37,53.94 77.37,55.27 77.06,55.58 74.17,55.58 73.31,56.44 73.31,59.62 74.1,60.41 75.57,60.41 76.19,61.03 76.69,61.03 77.03,61.37 77.03,61.57 v1(76.89,61.71) ; 71.32,49.24 v2(71.11,49.24)
M_CHA_CLK0#: length 138.2
  TOP w0.216: U3.K7 79.14,38.5 79.14,37.78 v1(78.24,36.89) ; v1(78.61,25.7) 78.64,25.7 79.18,26.25 U2.K7 ; v1(79.02,68.92) 78.91,69.04 78.91,69.61 U5.K7 ; v1(77.84,57.24) 78.21,57.24 78.72,57.75 78.72,57.89 U4.K7
  TOP w0.254: R28.1 71.94,50.6 v1(71.81,50.74)
  IN1 w0.254: v1(78.24,36.89) 78.23,36.89 77.89,37.23 77.67,37.23 77.49,37.04 77.49,34.81 76.99,34.31 76.99,34.1 77.11,33.98 77.31,33.98 77.67,33.62 77.67,33.08 77.04,32.44 77.04,32.24 77.32,31.96 v1(77.32,31.89) ; v1(77.55,61.71) 77.37,61.54 77.37,61.03 77.05,60.71 76.14,60.71 76,60.57 76,60.36 76.27,60.09 77.09,60.09 77.46,59.71 77.46,58.95 77.24,58.73 77.24,58.5 77.55,58.19 77.55,57.56 77.84,57.27 v1(77.84,57.24)
  IN2 w0.343: v1(44.96,46.37) 45.34,46.76 45.34,46.89 45.64,47.19 46.81,47.19 47.27,47.64 47.27,48.82 47.57,49.11 49.49,49.11 49.86,48.74 49.86,47.55 50.38,47.03 51.44,47.03 51.94,47.54 51.94,48.06 52.24,48.35 53.33,48.35 53.75,47.93 53.75,46.31 54.37,45.69 55.43,45.69 55.95,46.21 55.95,46.9 56.26,47.21 56.77,47.21 57.46,46.52 59.47,46.52 59.95,47.01 59.95,47.9 59.44,48.42 58.31,48.42 57.46,49.27 57.46,49.73 57.89,50.16 58.19,50.16 58.93,49.42 59.79,49.42 60.23,49.85 60.23,51.1 60.41,51.28 60.93,51.28 61.6,50.62 66.25,50.62 66.8,51.17 66.8,51.51 67.05,51.75 67.76,51.75 68.01,51.5 68.01,50.75 68.6,50.16 71.46,50.16 71.81,50.51 v1(71.81,50.74)
  IN3 w0.216: v1(77.32,31.89) 77.16,31.74 77.16,31.16 76.86,30.87 76.86,30.73 77.17,30.42 77.9,30.42 78.3,30.02 78.3,26.62 78.61,26.31 v1(78.61,25.7) ; v1(79.02,68.92) 78.78,68.67 78.78,64.41 77.45,63.09 77.45,61.82 77.44,61.82 v1(77.55,61.71)
  BOTTOM w0.089: v1(44.96,46.37) 44.96,45.56 44.32,44.92 41.98,44.92 41.97,44.93 41.59,44.93 U1.AU37
  BOTTOM w0.254: v2(71.92,52.01) 71.7,52.01 ; 71.7,52.01 71.7,50.85 v1(71.81,50.74) 71.68,50.61 71.68,48.1 72.54,47.24 72.54,41.6 72.9,41.24 73.21,41.24 74.04,40.41 74.04,39.77 73.33,39.06 73.33,37.93 74,37.27 74.84,37.27 75.31,36.8 75.31,36.29 74.83,35.81 74.83,34.28 75.08,34.03 75.62,34.03 76,34.41 77.04,34.41 77.4,34.04 77.4,32.82 77.15,32.57 77.15,32.06 v1(77.32,31.89) ; 71.7,52.01 71.7,53.44 72.71,54.45 74.2,54.45 74.57,54.08 74.57,53.19 75.05,52.7 76.64,52.7 77.73,53.79 77.73,55.41 77.2,55.94 74.32,55.94 73.67,56.59 73.67,59.47 74.24,60.05 75.71,60.05 76.33,60.67 76.83,60.67 77.38,61.22 77.38,61.55 v1(77.55,61.71)
M_CHA_CS#0: length 141.9
  TOP w0.102: 77.92,52.29 77.92,52.61 78.15,52.84 v1(79.01,52.84) ; v1(79.58,34.95) 80.07,34.95 80.32,35.2 80.44,35.2 80.65,34.99 80.65,34.89 80.44,34.68 80.44,34.39 80.65,34.18 80.65,34.09 80.46,33.9 80.32,33.9 80,34.22 80,34.31 79.98,34.33 U3.L2 ; U2.L2 80.38,23.41 v1(80.38,23.41) ; U4.L2 79.98,54.04 80.32,53.7 80.32,53.02 v1(79.85,52.55) ; v1(79.58,66.29) 79.88,66.29 79.98,66.19 U5.L2
  TOP w0.267: R4.1 76.84,49.74 76.84,51.05 77.54,51.75 77.54,51.91 77.92,52.29
  IN2 w0.089: v1(39.72,48.56) 39.72,48.8 43.91,52.99 44.77,52.99 46.59,54.81 49.51,54.81
  IN2 w0.33: 49.51,54.81 52.01,54.81 57.27,60.06 63.22,60.06 64.69,61.53 66.21,61.53 66.7,62.02 69.31,62.02 69.99,61.34 73.58,61.34 74.8,60.11 75.87,60.11 77.78,58.21 78.28,58.21 78.86,57.63 78.86,57.15 80.12,55.89 80.12,54.53 79.02,53.43 79.02,52.85 v1(79.01,52.84)
  IN3 w0.102: v1(79.58,32.71) 79.58,33.45 80.13,33.99 80.13,36.56 79.2,37.49 79.2,38.52 79.11,38.61 79.11,42.79 79.24,42.92 79.24,50.66 79.39,50.81 79.39,52.47 v1(79.01,52.84) 79.01,53.45 79.2,53.64 79.2,54.24 79.3,54.34 79.9,54.34 80,54.24 80,53 80.1,52.9 80.42,52.9 80.52,53 80.52,53.38 80.75,53.61 80.75,55.01 80.58,55.18 79.32,55.18 79.21,55.28 79.21,56.72 79.32,56.82 79.83,56.82 79.94,56.72 79.94,56.54 80.04,56.44 81.29,56.44 81.43,56.58 81.43,57.3 81.25,57.49 81.04,57.49 80.82,57.27 80.33,57.27 80.23,57.38 80.23,57.89 80.44,58.11 80.44,58.26 80.16,58.54 79.99,58.54 79.79,58.34 79.26,58.34 79.16,58.44 79.16,60.88 79.27,60.99 v1(79.58,60.99)
  BOTTOM w0.089: U1.AP33 39.38,48.16 39.72,48.5 v1(39.72,48.56)
  BOTTOM w0.102: v1(80.38,23.41) 80.38,23.42 80.38,25.92 80.16,26.13 80.16,27.5 79.05,28.62 79.05,31.18 78.87,31.36 78.87,32.3 79.27,32.71 v1(79.58,32.71) 79.88,32.71 80.05,32.87 80.05,33.19 79.95,33.29 79.53,33.29 78.92,32.68 78.74,32.68 78.61,32.81 78.61,32.94 79.35,33.67 80.01,33.67 80.11,33.77 80.11,34.87 80.04,34.95 v1(79.58,34.95) ; v1(79.58,66.29) 79.58,65.98 79.5,65.9 79.38,65.9 78.99,65.52 78.82,65.52 78.71,65.63 78.71,65.8 79.05,66.13 79.05,66.64 79.12,66.72 79.88,66.72 80.22,66.39 80.22,64.69 80.14,64.61 v2(80.14,64.08) 80.14,63.8 80.04,63.7 79.88,63.7 79.79,63.6 79.79,63.35 79.89,63.25 80.07,63.25 80.19,63.13 80.19,62.96 80.07,62.84 79.89,62.84 79.79,62.74 79.79,62.26 80,62.04 80,61.12 79.87,60.99 v1(79.58,60.99) 79.16,60.57 79.16,57 79.7,56.46 79.7,55.82 80.22,55.3 80.22,54.45 80,54.23 80,52.69 v1(79.85,52.55)
M_CHA_CS#1: length 139.9
  TOP w0.102: U5.L1 79.58,65.49 v1(79.58,65.49) ; U3.L1 79.99,33.74 80.27,33.47 80.27,33.27 80.14,33.14 79.5,33.14 79.38,33.26 79.38,33.45 79.58,33.65 v1(79.58,34.14) ; v1(79.58,54.76) 79.58,53.71 79.74,53.55 U4.L1 ; U2.L1 79.98,22.22 v1(79.58,22.61)
  TOP w0.267: v1(78.46,52.18) 77.93,51.66 77.93,50.74 R26.1
  IN2 w0.089: v1(40.7,49.22) 44.14,52.65 44.69,52.65 46.46,54.42 49.37,54.42 49.51,54.28
  IN2 w0.33: 49.51,54.28 52.23,54.28 53.31,55.36 54.1,55.36 54.41,55.68 54.41,56.46 54.78,56.84 55.7,56.84 56.21,57.35 56.21,58.27 57.49,59.54 63.79,59.54 64.29,60.04 66.5,60.04 67.19,60.73 67.19,61.01 67.52,61.34 68.18,61.34 68.51,61.01 68.51,60.57 68.84,60.24 71.76,60.24 71.91,60.09 73.69,60.09 74.12,59.66 74.12,58.89 74.79,58.22 76.7,58.22 77.15,57.78 78.1,57.78 78.41,57.46 78.41,56.96 77.88,56.43 77.88,53.1 78.46,52.52 v1(78.46,52.18)
  IN3 w0.102: v1(78.21,32.53) 78.34,32.66 78.34,32.69 78.63,32.99 78.63,34.88 77.45,36.06 77.45,40.78 77.66,41 77.66,45.78 78,46.12 78,50.74 78.18,50.92 78.18,51.91 v1(78.46,52.18) 78,52.18 77.9,52.29 77.9,52.41 77.81,52.5 77.81,52.72 77.92,52.82 78.26,52.82 78.36,52.93 78.36,53.4 78.28,53.48 78.06,53.48 77.9,53.33 77.78,53.33 77.42,53.69 77.42,53.81 77.55,53.94 78.03,53.94 78.16,54.07 78.16,54.84 78.1,54.89 77.88,54.89 77.8,54.82 77.8,54.56 77.69,54.45 77.53,54.45 77.42,54.56 77.42,55.3 77.52,55.4 78.05,55.4 78.16,55.5 78.16,55.64 78.05,55.74 77.52,55.74 77.42,55.85 77.42,55.98 77.52,56.08 78.05,56.08 78.16,56.18 78.16,56.3 78.16,56.66 78.44,56.94 78.63,56.94 78.76,57.07 78.76,57.52 78.65,57.62 78.39,57.62 78.26,57.76 78.26,57.85 78.36,57.95 78.65,57.95 78.76,58.06 78.76,58.67 78.65,58.77 78.5,58.77 78.4,58.67 78.4,58.55 78.18,58.34 77.68,58.34 77.55,58.47 77.55,59.91 77.65,60.01 78.13,60.01 78.33,59.82 78.6,59.82 78.76,59.98 78.76,60.78 78.67,60.88 78,60.88 77.9,60.98 77.9,61.19 78.17,61.46 78.17,61.59 78.27,61.69 78.49,61.69 78.59,61.59 v1(78.59,61.41)
  BOTTOM w0.089: v1(40.7,49.22) 40.27,49.22 U1.AR32
  BOTTOM w0.102: v1(79.58,54.76) 79.31,54.76 79.21,54.86 79.21,56.37 78.76,56.83 78.76,58.11 78.53,58.34 77.75,58.34 77.54,58.55 77.54,60.61 77.78,60.86 78.37,60.86 78.59,61.08 v1(78.59,61.41) 79.16,61.98 79.16,62.04 79.3,62.18 79.3,63.29 79.02,63.57 77.29,63.57 77.19,63.67 77.19,63.87 77.29,63.97 79.1,63.97 79.17,64.05 79.17,64.36 79.07,64.46 78.28,64.46 78.18,64.56 v2(78.18,64.69) 78.18,64.76 78.28,64.86 78.96,64.86 v1(79.58,65.49) ; v1(79.58,22.61) 79.58,24.63 79.2,25.01 79.2,25.98 77.78,27.4 77.78,32.1 v1(78.21,32.53) 77.88,32.53 77.75,32.66 77.75,33.57 77.9,33.72 78.28,33.72 78.61,33.39 78.78,33.39 79.15,33.76 79.15,33.98 79.05,34.08 78.49,34.08 78.41,34.15 78.41,34.36 78.51,34.46 78.72,34.46 78.82,34.56 78.82,34.74 78.74,34.82 78.49,34.82 78.41,34.89 78.41,35.11 78.51,35.21 79.05,35.21 79.15,35.11 79.15,34.61 79.22,34.54 79.5,34.54 79.58,34.46 v1(79.58,34.14)
M_CHA_DQ0: length 53.3
  TOP w0.089: v1(35.03,26.64) 34.36,25.97 v2(34.36,25.87)
  TOP w0.102: v1(77.22,25.08) 77.7,24.6 77.7,23.93 U2.H3
  IN3 w0.089: 46.64,23.89 45.83,24.7 37.88,24.7 37.64,24.46 36,24.46 34.87,25.59 34.87,26.48 v1(35.03,26.64)
  IN3 w0.178: 46.64,23.89 49.91,20.62 66.7,20.62 69.93,23.84 69.93,24.02 70.13,24.22 72.26,24.22 72.49,23.99 76.13,23.99 v1(77.22,25.08)
  BOTTOM w0.089: U1.AH63 35.79,27.4 v1(35.03,26.64)
M_CHA_DQ1: length 54.5
  TOP w0.089: v2(34.14,27.71) 34.56,27.28 v1(35.03,27.28)
  TOP w0.102: v1(77.26,24.26) 77.12,24.13 77.12,23.35 U2.G2
  IN3 w0.089: 45.24,23.89 44.61,24.52 37.95,24.52 37.71,24.28 35.93,24.28 34.63,25.58 34.63,26.88 v1(35.03,27.28)
  IN3 w0.178: 45.24,23.89 48.88,20.25 67.35,20.25 69.78,22.67 72.86,22.67 73.42,22.12 74.4,22.12 75.44,23.16 76.15,23.16 v1(77.26,24.26)
  BOTTOM w0.089: U1.AH62 35.58,29.52 35.58,29.4 35.51,29.24 35.51,28.93 35.61,28.83 35.61,27.86 v1(35.03,27.28)
M_CHA_DQ2: length 47.4
  TOP w0.089: v1(37.19,26.79) 37.44,26.53 v2(37.85,26.53)
  TOP w0.102: v1(75.59,26.58) 75.59,27.42 U2.F8
  IN3 w0.089: 47.54,25.67 47.6,25.67 47.28,26 37.98,26 v1(37.19,26.79)
  IN3 w0.178: 47.54,25.67 49.6,23.61 51.72,23.61 52.25,23.08 58.52,23.08 60.53,25.09 64.25,25.09 64.71,25.54 65.61,25.54 68,27.93 71.55,27.93 71.78,27.7 72.75,27.7 73.08,27.37 74.8,27.37 v1(75.59,26.58)
  BOTTOM w0.089: U1.AK63 37.14,28.82 37.49,28.47 37.49,27.09 v1(37.19,26.79)
M_CHA_DQ3: length 49.7
  TOP w0.089: v2(35.84,26.87) 36.09,26.87 36.81,26.15 v1(37.19,26.15)
  TOP w0.102: v1(75.62,25.92) 76.01,26.32 76.01,26.98 U2.F7
  IN3 w0.089: v1(37.19,26.15) 37.57,25.77 46.89,25.77
  IN3 w0.178: 46.89,25.77 49.42,23.25 51.54,23.25 52.12,22.66 58.63,22.66 60.11,24.15 63.84,24.15 64.85,25.17 65.82,25.17 68.16,27.51 71.07,27.51 71.16,27.42 72.63,27.42 72.96,27.09 74.69,27.09 75.08,26.7 75.08,26.44 75.4,26.13 75.41,26.13 v1(75.62,25.92)
  BOTTOM w0.089: v1(37.19,26.15) 37.67,26.64 37.67,28.58 37.52,28.73 37.52,29.45 U1.AK62
M_CHA_DQ4: length 54.5
  TOP w0.102: v1(76.38,22.61) 76.38,22.61 U2.F2
  IN3 w0.089: 44.72,23.89 44.27,24.34 38.1,24.34 37.82,24.06 35.9,24.06 34.45,25.51 34.45,27.38 v1(35.03,27.96)
  IN3 w0.178: 44.72,23.89 48.73,19.88 67.74,19.88 70.13,22.26 72.58,22.26 72.98,21.87 72.98,21.56 73.51,21.02 74.79,21.02 75.26,21.49 75.26,21.82 76.04,22.61 v1(76.38,22.61)
  BOTTOM w0.089: U1.AH61 35.4,29.91 35.4,29.44 35.33,29.28 35.33,28.85 35.43,28.75 35.43,28.36 v1(35.03,27.96) 35.03,27.86 34.6,27.42 34.6,27.09 v2(34.39,26.88)
M_CHA_DQ5: length 55.5
  TOP w0.089: v1(36.56,27.69) 36.09,28.16 v2(36.09,28.97)
  TOP w0.102: v1(76.23,29.79) 76.35,29.79 77.19,28.95 77.72,28.95 77.92,28.75 77.92,28.36 77.58,28.02 U2.H8
  IN3 w0.089: 48.67,25.3 48.67,25.7 47.97,26.4 43.4,26.4 42.52,27.27 42.52,27.4 40.73,29.19 38.06,29.19 v1(36.56,27.69)
  IN3 w0.178: 48.67,25.3 49.61,24.35 53.01,24.35 53.42,23.95 58.3,23.95 60.33,25.98 62.82,25.98 64.01,27.17 65.48,27.17 69.34,31.03 74.98,31.03 v1(76.23,29.79)
  BOTTOM w0.089: U1.AH60 36.56,31.13 36.77,30.93 36.77,30.68 36.75,30.66 36.75,30.36 36.75,30.36 36.75,30.09 36.68,29.93 36.68,29.72 36.75,29.57 36.75,29.44 36.68,29.28 36.68,28.77 36.96,28.49 36.96,28.09 v1(36.56,27.69)
M_CHA_DQ6: length 52.9
  TOP w0.089: v1(36.59,27.07) 37.82,28.31 v2(37.82,28.54)
  TOP w0.102: U2.H7 77.19,26.62 v1(77.19,26.59)
  IN3 w0.089: v1(36.59,27.07) 38.33,28.82 39.3,28.82 41.33,26.79 41.33,26.75 41.9,26.17 47.41,26.17
  IN3 w0.178: v1(77.19,26.59) 77.19,26.74 76.53,27.4 75.36,27.4 75.11,27.65 73.31,27.65 72.52,28.44 67.98,28.44 65.5,25.95 64.42,25.95 64.01,25.54 60.42,25.54 58.46,23.58 53.26,23.58 52.86,23.98 49.6,23.98 47.41,26.17
  BOTTOM w0.089: U1.AK61 37.04,30.15 36.93,30.05 36.86,29.89 36.86,29.76 36.93,29.61 36.93,29.4 36.86,29.24 36.86,28.85 37.31,28.39 37.31,27.8 v1(36.59,27.07)
M_CHA_DQ7: length 51.9
  TOP w0.102: U2.E3 74.93,24.06 v1(74.93,25.9)
  IN3 w0.089: 46.84,25.23 46.47,25.6 37.26,25.6 v1(37.16,25.49)
  IN3 w0.178: v1(74.93,25.9) 74.81,25.78 74.2,25.78 74.03,25.95 73.71,25.95 72.52,27.14 68.32,27.14 66.84,25.67 66.84,24.49 66.13,23.78 60.55,23.78 59.06,22.3 51.89,22.3 51.31,22.88 49.25,22.88 46.9,25.23 46.84,25.23
  BOTTOM w0.089: 37.29,25.37 v1(37.16,25.49) 37.64,25.98 37.64,26.36 37.85,26.56 37.85,28.66 37.75,28.76 37.75,29.47 37.7,29.52 37.44,29.89 37.32,30.15 37.32,30.36 37.32,30.36 37.32,30.6 37.26,30.72 37.16,30.89 U1.AK60
  BOTTOM w0.191: 37.29,25.37 37.34,25.32 v2(37.34,24.5)
M_CHA_DQ8: length 41.5
  TOP w0.102: v1(72.38,23.41) U2.A3
  IN1 w0.089: 47.35,25.52 40.57,25.52 v1(39.42,26.66)
  IN1 w0.229: v1(72.38,23.41) 71.18,22.22 70.05,22.22 68.78,20.94 59.73,20.94 57.69,22.98 53.54,22.98 52.62,23.91 48.96,23.91 47.35,25.52
  BOTTOM w0.089: v2(39.88,25.42) 39.88,26.2 v1(39.42,26.66) 39.01,27.08 38.84,27.08 38.22,27.69 38.22,27.74 38.21,27.75 38.21,28.82 38.22,28.83 U1.AM63
M_CHA_DQ9: length 40.3
  TOP w0.102: U2.A2 71.34,23.01 v1(71.21,23.13)
  IN1 w0.089: v1(39.42,27.3) 40.95,25.77 47.78,25.77
  IN1 w0.229: v1(71.21,23.13) 69.85,23.13 69.24,22.52 69.24,21.99 68.6,21.36 59.91,21.36 57.86,23.4 53.72,23.4 52.79,24.33 49.23,24.33 47.78,25.77
  BOTTOM w0.089: U1.AM62 38.43,29.62 38.43,29.41 38.51,29.24 38.51,28.86 38.39,28.74 38.39,27.82 38.92,27.3 v1(39.42,27.3)
  BOTTOM w0.102: v2(71.07,22.39) 71.07,22.99 v1(71.21,23.13)
M_CHA_DQ10: length 42.8
  TOP w0.102: U2.D7 74.38,27 v1(73.99,26.61)
  IN1 w0.089: v1(42.04,26.6) 42.46,26.6 42.72,26.87 42.72,27.42 43.03,27.73 46.71,27.73 47.14,27.3
  IN1 w0.229: 47.14,27.3 51.62,27.3 54.24,24.67 58.6,24.67 59.56,23.71 66.74,23.71 67.42,24.39 67.42,25.15 69.45,27.17 70.89,27.17 72.06,26 73.39,26 v1(73.99,26.61)
  BOTTOM w0.089: v1(42.04,26.6) 41.86,26.78 41.38,26.78 41.27,26.9 41.21,26.9 40.88,27.24 40.88,27.29 40.64,27.53 40.35,27.53 39.74,28.14 39.74,28.74 39.57,28.9 U1.AP63
  BOTTOM w0.102: v1(73.99,26.61) 74.56,27.18 v2(74.86,27.18)
M_CHA_DQ11: length 40.2
  TOP w0.102: v1(72.24,26.51) 72.24,26.75 U2.A7
  IN1 w0.089: 49.81,27.72 48.81,27.72 48.59,27.93 42.73,27.93 v1(42.01,27.21)
  IN1 w0.229: v1(72.24,26.51) 72.24,26.53 71.17,27.6 69.28,27.6 67.01,25.32 67.01,24.63 66.5,24.13 59.73,24.13 58.77,25.09 54.42,25.09 51.79,27.72 49.81,27.72
  BOTTOM w0.089: U1.AP62 39.86,29.54 39.86,28.87 39.92,28.81 39.92,28.21 40.42,27.71 40.77,27.71 41.05,27.42 41.05,27.31 41.29,27.07 41.87,27.07 v1(42.01,27.21)
  BOTTOM w0.102: v1(72.24,26.51) v2(71.48,26.51)
